File: EEZ_BB3_CM4_R1B0/EEZ_BB3_CM4_R1B0.kicad_sch (KiCad schematic)
At the start: 0 parts

Commit message: Importing BP3
Other:
- removed sheet BP3C
