File: EEZ_DIB_MCU_r3B4/Ethernet_PHY.kicad_sch (KiCad schematic)
At the start: 44 parts, among them IC15 N.C., IC16 DP83848CVV/NOPB, X5 LMJTAB881243M-L

Commit message: Switching MCU to KiCad 7 - moving MCU and SDRAM from board
