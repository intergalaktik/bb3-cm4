File: EEZ_BB3_CM4_H7/STM32H7_MCU.kicad_sch (KiCad schematic)
At the start: 66 parts, among them IC2 STM32H757IIT6, IC3 AP1117-33, Y1 XTAL016178-85SMX

Commit message: Adding USB
Connections:
- net RS485_RX: now reaches IC2.26 (PF6)
- net RS485_TX: now reaches IC2.27 (PF7)
- net RS485_EN: now reaches IC2.28 (PF8)
- net USB_OTG_FS_VBUS: now reaches IC2.128 (PA9)
- net USB_OTG_FS_OC: now reaches IC2.141 (PC11)
- net USB_OTG_FS_PSO: now reaches IC2.147 (PD4)
- net DOUT3: now reaches IC2.149 (PD6)
- net DIN3: now reaches IC2.150 (PD7)
- no-connect marks 11 -> 5

Commit message: Moving components - moving EEZ logo to top
Connections:
- no-connect marks 5 -> 6
Changed lines of the file:
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@@
   )
   (no_connect (at 59.69 91.44))
+  (no_connect (at 177.8 60.96))
   (no_connect (at 59.69 93.98))
   (no_connect (at 147.32 93.98))
