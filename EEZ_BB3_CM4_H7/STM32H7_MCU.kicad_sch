File: EEZ_BB3_CM4_H7/STM32H7_MCU.kicad_sch (KiCad schematic)
At the start: 64 parts, among them IC2 STM32H757IIT6, IC3 AP1117-33, Y1 XTAL016178-85SMX

Commit message: Fix #6
Parts:
- added C1: 100n, Library:C_0402_1005Metric, symbol Library:Envox_C-EUC0402
- added C2: 2u2, Library:C_0402_1005Metric, symbol Library:C-EUC0805
Connections:
- net GND: now also C1.1, C2.2
- net VDD_DSI: now reaches IC2.101 (VCAPDSI.101)
- net VDD_DSI: now also IC2.102 (VDD12DSI.102), IC2.108 (VDD12DSI.108), C1.2, C2.1
Changed lines of the file:
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@@
   (junction (at 185.42 104.14) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 229.87 57.15) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 233.68 95.25) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 219.202 68.326) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 273.05 101.6) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 233.68 74.93) (diameter 0) (color 0 0 0 0)
   )
@@
   (junction (at 232.41 144.78) (diameter 0) (color 0 0 0 0)
   )
+  (junction (at 279.4 101.6) (diameter 0) (color 0 0 0 0)
+  )
   (junction (at 61.722 168.91) (diameter 0) (color 0 0 0 0)
   )
@@
     (stroke (width 0.1524) (type solid))
   )
+  (wire (pts (xy 266.7 101.6) (xy 273.05 101.6))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 171.45 154.94) (xy 161.29 154.94))
     (stroke (width 0.1524) (type solid))
@@
     (stroke (width 0.1524) (type solid))
   )
+  (wire (pts (xy 236.22 59.69) (xy 229.87 59.69))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 269.24 76.2) (xy 269.24 78.74))
     (stroke (width 0.1524) (type solid))
@@
     (stroke (width 0.1524) (type solid))
   )
+  (wire (pts (xy 229.87 57.15) (xy 236.22 57.15))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 227.33 157.48) (xy 227.33 154.94))
     (stroke (width 0.1524) (type solid))
@@
     (stroke (width 0.1524) (type solid))
   )
+  (wire (pts (xy 229.87 59.69) (xy 229.87 57.15))
+    (stroke (width 0) (type default))
+  )
   (polyline (pts (xy 55.118 54.61) (xy 55.626 53.848))
     (stroke (width 0.1524) (type solid) (color 132 0 132 1))
@@
     (stroke (width 0) (type default))
   )
+  (wire (pts (xy 226.06 57.15) (xy 229.87 57.15))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 99.06 119.38) (xy 99.06 124.46))
     (stroke (width 0.1524) (type solid))
@@
     (stroke (width 0.1524) (type solid))
   )
+  (wire (pts (xy 273.05 101.6) (xy 279.4 101.6))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 233.68 86.36) (xy 233.68 90.17))
     (stroke (width 0.1524) (type solid))
@@
     (stroke (width 0.1524) (type solid))
   )
+  (wire (pts (xy 279.4 97.79) (xy 279.4 101.6))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 161.29 134.62) (xy 171.45 134.62))
     (stroke (width 0.1524) (type solid))
@@
     (effects (font (size 0.889 0.889)) (justify left bottom))
   )
+  (label "VDD_DSI" (at 226.06 57.15 0) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "VBAT" (at 228.6 25.4 0) (fields_autoplaced)
     (effects (font (size 0.889 0.889)) (justify left bottom))
@@
     (effects (font (size 0.889 0.889)) (justify left bottom))
   )
+  (label "VDD_DSI" (at 279.4 97.79 90) (fields_autoplaced)
+    (effects (font (size 1.27 1.27)) (justify left bottom))
+  )
   (label "RCC_OSC_IN" (at 137.16 119.38 0) (fields_autoplaced)
     (effects (font (size 0.889 0.889)) (justify left bottom))
@@
     )
   )
+  (symbol (lib_id "Envox H745 Master MCU r2B6-eagle-import:GND") (at 279.4 111.76 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#SUPPLY02" (at 279.4 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 276.86 111.76 90)
+      (effects (font (size 1.778 1.5113)) (justify left bottom))
+    )
+    (property "Footprint" "" (at 279.4 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 279.4 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "H745 CM4 module"
+        (path "/1a4f0aea-3a69-423f-8790-3103cd0321c4/d7166dbe-caf3-45a8-82fe-1ff0a9696e25"
+          (reference "#SUPPLY02") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Envox H745 Master MCU r2B6-eagle-import:GND") (at 229.87 110.49 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
     )
   )
+  (symbol (lib_id "Library:Envox_C-EUC0402") (at 273.05 106.68 180) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "C1" (at 272.669 104.521 90)
+      (effects (font (size 1.778 1.5113)) (justify right top))
+    )
+    (property "Value" "100n" (at 275.209 104.521 90)
+      (effects (font (size 1.778 1.5113)) (justify right top))
+    )
+    (property "Footprint" "Library:C_0402_1005Metric" (at 273.05 106.68 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 273.05 106.68 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "H745 CM4 module"
+        (path "/1a4f0aea-3a69-423f-8790-3103cd0321c4/d7166dbe-caf3-45a8-82fe-1ff0a9696e25"
+          (reference "C1") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Envox H745 Master MCU r2B6-eagle-import:+3V3") (at 180.848 15.24 90) (mirror x) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
     )
   )
+  (symbol (lib_id "Envox H745 Master MCU r2B6-eagle-import:GND") (at 273.05 111.76 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "#SUPPLY01" (at 273.05 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Value" "GND" (at 270.51 111.76 90)
+      (effects (font (size 1.778 1.5113)) (justify left bottom))
+    )
+    (property "Footprint" "" (at 273.05 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 273.05 111.76 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (instances
+      (project "H745 CM4 module"
+        (path "/1a4f0aea-3a69-423f-8790-3103cd0321c4/d7166dbe-caf3-45a8-82fe-1ff0a9696e25"
+          (reference "#SUPPLY01") (unit 1)
+        )
+      )
+    )
+  )
   (symbol (lib_id "Library:Envox_R-EU_R0402") (at 206.375 20.32 0) (unit 1)
     (in_bom yes) (on_board yes) (dnp no)
@@
         )
       )
+    )
+  )
+  (symbol (lib_id "Library:C-EUC0805") (at 279.4 104.14 0) (mirror y) (unit 1)
+    (in_bom yes) (on_board yes) (dnp no)
+    (property "Reference" "C2" (at 278.892 104.2924 0)
+      (effects (font (size 1.778 1.5113)) (justify left bottom))
+    )
+    (property "Value" "2u2" (at 284.48 104.14 0)
+      (effects (font (size 1.778 1.5113)) (justify left bottom))
+    )
+    (property "Footprint" "Library:C_0402_1005Metric" (at 279.4 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Datasheet" "" (at 279.4 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (property "Mouser PN" "KGM05AR51A225MH " (at 279.4 104.14 0)
+      (effects (font (size 1.27 1.27)) hide)
+    )
+    (pin "1")
+    (pin "2")
+    (instances
+      (project "H745 CM4 module"
+        (path "/1a4f0aea-3a69-423f-8790-3103cd0321c4/d7166dbe-caf3-45a8-82fe-1ff0a9696e25"
+          (reference "C2") (unit 1)
+        )
+      )

Commit message: Updating pinout
Connections:
- net ETH_TXD1: now also IC2.156 (PG12); no longer IC2.158 (PG14)
- net SPI5_CSA: now also IC2.29 (PF9); no longer IC2.26 (PF6)
- no-connect marks 13 -> 11
Changed lines of the file:
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@@
   (no_connect (at 90.17 78.74))
   (no_connect (at 90.17 86.36))
-  (no_connect (at 147.32 91.44))
   (no_connect (at 147.32 88.9))
   (no_connect (at 177.8 50.8))
-  (no_connect (at 177.8 55.88))
   (no_connect (at 177.8 48.26))
   (wire (pts (xy 130.81 147.32) (xy 140.97 147.32))
@@
     (stroke (width 0.1524) (type solid))
   )
-  (wire (pts (xy 177.8 60.96) (xy 184.15 60.96))
-    (stroke (width 0.1524) (type solid))
-  )
   (wire (pts (xy 61.722 168.91) (xy 56.642 168.91))
     (stroke (width 0.1524) (type solid))
@@
     (stroke (width 0.1524) (type solid))
   )
+  (wire (pts (xy 142.24 91.44) (xy 147.32 91.44))
+    (stroke (width 0) (type default))
+  )
   (wire (pts (xy 216.662 83.566) (xy 217.17 83.566))
     (stroke (width 0.1524) (type solid))
@@
   (wire (pts (xy 269.24 64.77) (xy 269.24 76.2))
     (stroke (width 0.1524) (type solid))
+  )
+  (wire (pts (xy 177.8 55.88) (xy 184.15 55.88))
+    (stroke (width 0) (type default))
   )
   (wire (pts (xy 247.65 154.94) (xy 247.65 157.48))
@@
     )
   )
-  (global_label "ETH_TXD1" (shape bidirectional) (at 184.15 60.96 0) (fields_autoplaced)
-    (effects (font (size 0.889 0.889)) (justify left))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 193.3673 60.96 0)
+  (global_label "ETH_TXD1" (shape bidirectional) (at 184.15 55.88 0) (fields_autoplaced)
+    (effects (font (size 0.889 0.889)) (justify left))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 193.3673 55.88 0)
       (effects (font (size 1.27 1.27)) (justify left) hide)
     )
@@
     )
   )
-  (global_label "SPI5_CSA" (shape input) (at 140.97 83.82 180) (fields_autoplaced)
-    (effects (font (size 0.889 0.889)) (justify right))
-    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 132.7554 83.82 0)
-      (effects (font (size 1.27 1.27)) (justify right) hide)
-    )
+  (global_label "SPI5_CSA" (shape input) (at 142.24 91.44 180) (fields_autoplaced)
+    (effects (font (size 0.889 0.889)) (justify right))
+    (property "Intersheetrefs" "${INTERSHEET_REFS}" (at 134.0254 91.44 0)
+      (effects (font (size 1.27 1.27)) (justify right) hide)
+    )
