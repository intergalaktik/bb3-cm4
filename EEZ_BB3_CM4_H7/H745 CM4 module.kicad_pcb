# Repository intergalaktik/bb3-cm4

File README.md:

# BB3 CM4

 CM4 compatible MCU board 

Tested and working on CM4 and ULX4M

HDMI, USB, Ethernet, DSI, SPI0

Currently not working / not tested

SPI1, SPI2, LCD, SD, PCIe, GPIO

Some pins like PWR_START ( that is needed for starting meanwell power supplys ) are connected to CAM pins on CM4 connector

https://youtu.be/SRumQEken4A?si=kqTtNezlvHsmelDW

## Work on this board is financed by NLnet foundation

This project was funded through the NGI0 Entrust Fund, a fund established by NLnet with financial support from the European Commission's Next Generation Internet programme, under the aegis of DG Communications Networks, Content and Technology under grant agreement No 101069594.

https://nlnet.nl/project/BB3-CM4

## Check up our blogposts

## Contact us

Discord: https://discord.gg/qwMUk6W

## ULX4M

https://github.com/intergalaktik/ulx4m

## KiCad design EEZ_BB3_CM4_H7/H745 CM4 module.kicad_pcb

File EEZ_BB3_CM4_H7/README.md:

# BB3 CM4 H7

 CM4 compatible H7 MCU board 

## Work on this board is financed by NLnet foundation

This project was funded through the NGI0 Entrust Fund, a fund established by NLnet with financial support from the European Commission's Next Generation Internet programme, under the aegis of DG Communications Networks, Content and Technology under grant agreement No 101069594.

https://nlnet.nl/project/BB3-CM4

## Check up our blogposts

## Contact us

Discord: https://discord.gg/qwMUk6W

## ULX4M

https://github.com/intergalaktik/ulx4m

Parts:
C60: 470p; C_0402_1005Metric
C61: 1u; C_0402_1005Metric
C62, C63, C67, C68: 100n; C_0402_1005Metric
C65, C66: 10u; EC1206
IC12: LAN8742A-CZ-TR; SQFN24_4X4MC_MCH-M
L6: BLM18AG102SH1D; BEAD0603
R27: 100R; R_0402_1005Metric
R28: 1K5; R_0402_1005Metric
R29: 12K1 1%; R_0402_1005Metric
R31, R32: 10K; R_0402_1005Metric
R33, R34, R35, R36: 49R9; R_0402_1005Metric
RN6: DR1206-33R-4/8; CAY16
RN7: DR1206-10K-4/8; CAY16

Connections:
/Ethernet PHY, Audio, DACs/+3V3_LAN: C62.1, C63.1, C65.+, C67.2, C68.2, IC12.1 (VDD2A), IC12.19 (VDD1A), L6.P$1 (1), R33.1, R34.2, R35.1, R36.2
/Ethernet PHY, Audio, DACs/CRS_IN: IC12.11 (CRS_DV/~MODE2), RN6.6 (2), RN7.6 (2)
/Ethernet PHY, Audio, DACs/ETH_CLK_IN: IC12.5 (XTAL1/CLKIN), R27.1
/Ethernet PHY, Audio, DACs/RXD0_IN: IC12.8 (RXD0/~MODE0), RN6.7 (2), RN7.7 (2)
/Ethernet PHY, Audio, DACs/RXD1_IN: IC12.7 (RXD1/~MODE1), RN6.8 (2), RN7.5 (2)
CM4_3.3V: C66.+, IC12.9 (VDDIO), L6.P$2 (2), R28.2, RN7.1, RN7.2 (1), RN7.3 (1), RN7.4 (1); also elsewhere on the board
ETH_0N: IC12.20 (TXN), R34.1; also elsewhere on the board
ETH_0P: IC12.21 (TXP), R33.2; also elsewhere on the board
ETH_1N: IC12.22 (RXN), R36.1; also elsewhere on the board
ETH_1P: IC12.23 (RXP), R35.2; also elsewhere on the board
ETH_CRS_DV: RN6.3 (1); also elsewhere on the board
ETH_MDC: IC12.13 (MDC); also elsewhere on the board
ETH_MDIO: IC12.12 (MDIO), R28.1; also elsewhere on the board
ETH_REF_CLK: IC12.14 (NINT/REFCLKO), RN7.8 (2); also elsewhere on the board
ETH_RXD0: RN6.2 (1); also elsewhere on the board
ETH_RXD1: RN6.1; also elsewhere on the board
ETH_RX_ERR: IC12.10 (RXER/~PHYAD0)
ETH_TXD0: IC12.17 (TXD0); also elsewhere on the board
ETH_TXD1: IC12.18 (TXD1); also elsewhere on the board
ETH_TX_EN: IC12.16 (TXEN); also elsewhere on the board
ETH_nLED1: IC12.3 (LED1/NINT/NPME/~REGOFF), R32.2; also elsewhere on the board
ETH_nLED2: IC12.2 (LED2/NINT/NPME/~NINTSEL), R31.2; also elsewhere on the board
GND: C60.1, C61.1, C62.2, C63.2, C65.-, C66.-, C67.1, C68.1, IC12.25 (EPAD), R29.1, R31.1, R32.1; also elsewhere on the board
unnamed: IC12.24 (RBIAS), R29.2
unnamed: C60.2, C61.2, IC12.6 (VDDCR)
RCC_MCO_2: R27.2; also elsewhere on the board
~RESET: IC12.15 (NRST); also elsewhere on the board

Notes on the sheet:
Ethernet RMII PHY
RD matched Net Lengths [Tolerance = 100mil] Diff Pair 100ohm
TD matched Net Lengths [Tolerance = 100mil] Diff Pair 100ohm

Parts:
J1, J2: DF40C-100DP-0.4V(51); HRS_DF40C-100DP-0.4V(51); PARTREV 02/2020

Connections:
+5V: J1.77, J1.79, J1.81, J1.83, J1.85, J1.87; also elsewhere on the board
AUDIO_OUT: J1.96; also elsewhere on the board
AnalogIP1: J1.94; also elsewhere on the board
BOOT0: J1.93; also elsewhere on the board
BT_nDisable: J1.91
CAM0_C_N: J2.40; also elsewhere on the board
CAM0_C_P: J2.42; also elsewhere on the board
CAM0_D0_N: J2.28; also elsewhere on the board
CAM0_D0_P: J2.30; also elsewhere on the board
CAM0_D1_N: J2.34; also elsewhere on the board
CAM0_D1_P: J2.36; also elsewhere on the board
CAM1_C_N: J2.27
CAM1_C_P: J2.29
CAM1_D0_N: J2.15; also elsewhere on the board
CAM1_D0_P: J2.17; also elsewhere on the board
CAM1_D1_N: J2.21; also elsewhere on the board
CAM1_D1_P: J2.23
CAM1_D2_N: J2.33
CAM1_D2_P: J2.35
CAM1_D3_N: J2.39
CAM1_D3_P: J2.41
CM4_1.8V: J1.88, J1.90
CM4_3.3V: J1.84, J1.86; also elsewhere on the board
Camera_GPIO: J1.97
DAC_OUT1: J1.34; also elsewhere on the board
DIN2: J1.41; also elsewhere on the board
DIN3: J2.78; also elsewhere on the board
DOUT2: J1.29; also elsewhere on the board
DOUT3: J2.76; also elsewhere on the board
DSI0_C_N: J2.69; also elsewhere on the board
DSI0_C_P: J2.71; also elsewhere on the board
DSI0_D0_N: J2.57; also elsewhere on the board
DSI0_D0_P: J2.59; also elsewhere on the board
DSI0_D1_N: J2.63
DSI0_D1_P: J2.65
DSI1_C_N: J2.87
DSI1_C_P: J2.89
DSI1_D0_N: J2.75
DSI1_D0_P: J2.77
DSI1_D1_N: J2.81
DSI1_D1_P: J2.83
DSI1_D2_N: J2.93
DSI1_D2_P: J2.95
DSI1_D3_N: J2.94
DSI1_D3_P: J2.96
EEPROM_nWP: J1.20
ENC_A: J1.58; also elsewhere on the board
ENC_B: J1.56; also elsewhere on the board
ENC_SW: J1.45; also elsewhere on the board
ETH_0N: J1.10; also elsewhere on the board
ETH_0P: J1.12; also elsewhere on the board
ETH_1N: J1.6; also elsewhere on the board
ETH_1P: J1.4; also elsewhere on the board
ETH_2N: J1.9
ETH_2P: J1.11
ETH_3N: J1.5
ETH_3P: J1.3
ETH_SYNC_IN: J1.16
ETH_SYNC_OUT: J1.18
ETH_nLED1: J1.19; also elsewhere on the board
ETH_nLED2: J1.17; also elsewhere on the board
ETH_nLED3: J1.15
GLOBAL_EN: J1.99
GND: J1.1, J1.2, J1.7, J1.8, J1.13, J1.14, J1.22, J1.23, J1.32, J1.33, J1.42, J1.43, J1.52, J1.53, J1.59, J1.60, J1.65, J1.66, J1.71, J1.74, J1.98, J2.7, J2.8, J2.13, J2.14, J2.19, J2.20, J2.25, J2.26, J2.31, J2.32, J2.37, J2.38, J2.44, J2.50, J2.55, J2.56, J2.61, J2.62, J2.67, J2.68, J2.73, J2.74, J2.79, J2.80, J2.85, J2.86, J2.91, J2.92, J2.97, J2.98; also elsewhere on the board
GPIO4: J1.54; also elsewhere on the board
GPIO6: J1.30; also elsewhere on the board
GPIO7: J1.37; also elsewhere on the board
GPIO8: J1.39; also elsewhere on the board
GPIO9: J1.40; also elsewhere on the board
GPIO10: J1.44; also elsewhere on the board
GPIO11: J1.38; also elsewhere on the board
GPIO12: J1.31; also elsewhere on the board
GPIO13: J1.28; also elsewhere on the board
GPIO14: J1.55; also elsewhere on the board
GPIO15: J1.51; also elsewhere on the board
GPIO17: J1.50; also elsewhere on the board
GPIO18: J1.49; also elsewhere on the board
GPIO19: J1.26; also elsewhere on the board
GPIO20: J1.27; also elsewhere on the board
GPIO21: J1.25; also elsewhere on the board
GPIO22: J1.46; also elsewhere on the board
GPIO23: J1.47; also elsewhere on the board
GPIO26: J1.24; also elsewhere on the board
GPIO27: J1.48; also elsewhere on the board
GPIO_VREF: J1.78
HDMI0_CEC: J2.51
HDMI0_CLK_N: J2.90
HDMI0_CLK_P: J2.88; also elsewhere on the board
HDMI0_HOTPLUG: J2.53
HDMI0_SCL: J2.100; also elsewhere on the board
HDMI0_SDA: J2.99
HDMI0_TX0_N: J2.84; also elsewhere on the board
HDMI0_TX0_P: J2.82; also elsewhere on the board
HDMI0_TX2_N: J2.72
HDMI0_TX2_P: J2.70
HDMI1_CEC: J2.49
HDMI1_CLK_N: J2.66
HDMI1_CLK_P: J2.64
HDMI1_HOTPLUG: J2.43
HDMI1_SCL: J2.47
HDMI1_SDA: J2.45
HDMI1_TX0_N: J2.60
HDMI1_TX0_P: J2.58
HDMI1_TX1_N: J2.54
HDMI1_TX1_P: J2.52
HDMI1_TX2_N: J2.48
HDMI1_TX2_P: J2.46
I2C1_SCL: J1.80; also elsewhere on the board
I2C1_SDA: J1.82; also elsewhere on the board
ID_SC: J1.35; also elsewhere on the board
ID_SD: J1.36; also elsewhere on the board
PCIe_CLK_N: J2.12
PCIe_CLK_P: J2.10
PCIe_CLK_nREQ: J2.2
PCIe_RX_N: J2.18
PCIe_RX_P: J2.16
PCIe_TX_N: J2.24
PCIe_TX_P: J2.22
PCIe_nRST: J2.9
PI_LED_nPWR: J1.95
Pi_nLED_Activity: J1.21
RUN_PG: J1.92
SD_CLK: J1.57; also elsewhere on the board
SD_CMD: J1.62; also elsewhere on the board
SD_DAT0: J1.63; also elsewhere on the board
SD_DAT1: J1.67
SD_DAT2: J1.69
SD_DAT3: J1.61
SD_DAT4: J1.68
SD_DAT5: J1.64
SD_DAT6: J1.72
SD_DAT7: J1.70
SD_DETECT: J1.75; also elsewhere on the board
SD_VDD_Override: J1.73
USB_OTG_HS_D_N: J2.3; also elsewhere on the board
USB_OTG_HS_D_P: J2.5; also elsewhere on the board
USB_OTG_ID: J2.1; also elsewhere on the board
VDAC_COMP: J2.11
WL_nDisable: J1.89
nEXTRST: J1.100; also elsewhere on the board

Notes on the sheet:
CM4 needs to provide 3.3V to CM4 IO board

Parts:
C1, C9, C12, C13, C14, C15, C16, C17, C18, C19, C20, C23, C24, C25, C26, C27, C28, C29, C31, C32, C34, C36, C38, C44: 100n; C_0402_1005Metric
C2: 2u2; C_0402_1005Metric; Mouser PN KGM05AR51A225MH
C5, C6, C21, C22: 4p7; C_0402_1005Metric
C8: 10u; EC1206
C11, C35, C37, C39: 10u; C_0805_2012Metric
C30: CE5R5105HF-ZJ (1F)
C33, C42: 1u; C_0402_1005Metric
C40: 220p; C_0402_1005Metric
C41, C43: 4u7; C_0805_2012Metric
D1: RB751V40T1G; SOD323-R
FI1, FI2, FI3, FI4, FI5, FI6: FIDUCIAL; Fiducial_0.5mm_Mask1mm
H1, H2, H3, H4: HOLE; MountingHole_3.2mm_M3_ISO14580_Pad
IC2: STM32H757IIT6; LQFP176-24X24MM
IC3: AP1117-33; SOT-223-3_TabPin2
JP1: JP3-CUT-0805-ROTATED; JP3-0805-CUT2
L2: BLM18AG102SH1D; BEAD0603
L3: FBMJ1608HM180NTR; BEAD0603
L4: LQM2MPN2R2NG0; 0806
NT1, NT2: NetTie_2; NetTie-2_SMD_Pad0.5mm
R1, R3: 1K5; R_0402_1005Metric
R11: 10K; R_0402_1005Metric
R12: 180R; R_0402_1005Metric
R13: 47R; R_0603_1608Metric
XTAL1: TSX-3225; Oscillator_SMD_Abracon_ASE-4Pin_3.2x2.5mm
Y1: XTAL016178-85SMX; Crystal_SMD_2012-2Pin_2.0x1.2mm

Connections:
+5V: C11.2, C14.1, IC3.3 (VI); also elsewhere on the board
+VDD_MCU: C8.+, C9.1, C12.1, C13.1, C15.1, C16.1, C17.1, C18.1, C19.1, C20.1, C23.1, C24.1, C25.1, C26.1, C27.1, C28.1, C31.1, C32.1, C42.1, C44.1, IC2.7 (VDD.7), IC2.13 (VDD.13), IC2.25 (VDD.25), IC2.44 (VDD.44), IC2.48 (VDD.65), IC2.65 (VDD.48), IC2.71 (VDD.71), IC2.84 (VDD.84), IC2.92 (VDD.92), IC2.99 (VDD.99), IC2.113 (VDD.113), IC2.120 (VDD50USB), IC2.121 (VDD33USB), IC2.126 (VDD.126), IC2.136 (VDD.136), IC2.152 (VDD.152), IC2.160 (VDD.160), IC2.176 (VDD.176), JP1.NO, L2.P$1 (1), L3.P$2 (2), NT1.2
/STM32H7 MCU/RCC_OSC32_IN: C5.1, IC2.10 (PC14-OSC32_IN), Y1.2
/STM32H7 MCU/RCC_OSC32_OUT: C6.1, IC2.11 (PC15-OSC32_OUT), Y1.1
/STM32H7 MCU/RCC_OSC_IN: C21.2, IC2.31 (PH0-OSC_IN), XTAL1.3 (2)
/STM32H7 MCU/RCC_OSC_OUT: C22.2, IC2.32 (PH1-OSC_OUT), XTAL1.1
/STM32H7 MCU/VBAT: C38.1, D1.C, IC2.8 (VBAT), R12.2
/STM32H7 MCU/VDDA: C33.1, C34.1, IC2.40 (VDDA), L2.P$2 (2), R13.2
/STM32H7 MCU/VDDSMPS: C37.2, IC2.16 (VDDSMPS), L3.P$1 (1)
/STM32H7 MCU/VDD_DSI: C1.2, C2.1, IC2.101 (VCAPDSI.101), IC2.102 (VDD12DSI.102), IC2.108 (VDD12DSI.108)
/STM32H7 MCU/VDD_SDC: C33.2, C34.2, C39.2, C41.1, C43.1, IC2.17 (VFBSMPS), IC2.38 (VSSA), IC2.80 (VCAP.80), IC2.82 (VDDLDO.82), IC2.133 (VCAP.133), IC2.135 (VDDLDO.135), IC2.172 (VCAP.172), IC2.175 (VDDLDO.175), L4.1, NT2.2
/STM32H7 MCU/VLXSMPS: C40.1, IC2.15 (VLXSMPS), L4.2
/STM32H7 MCU/VREF+: C35.2, C36.2, IC2.39 (VREF+), R13.1
AUDIO_OUT: IC2.50 (PA5); also elsewhere on the board
AnalogIP1: IC2.9 (PC13); also elsewhere on the board
BOOT0: IC2.167 (BOOT0), IC2.174 (PDR_ON), JP1.COM, R11.2; also elsewhere on the board
CAM0_C_N: IC2.85 (PB12); also elsewhere on the board
CAM0_C_P: IC2.57 (PB2); also elsewhere on the board
CAM0_D0_N: IC2.95 (PD12); also elsewhere on the board
CAM0_D0_P: IC2.96 (PD13); also elsewhere on the board
CAM0_D1_N: IC2.55 (PB0); also elsewhere on the board
CAM0_D1_P: IC2.56 (PB1); also elsewhere on the board
CAM1_D0_N: IC2.26 (PF6); also elsewhere on the board
CAM1_D0_P: IC2.27 (PF7); also elsewhere on the board
CAM1_D1_N: IC2.28 (PF8); also elsewhere on the board
CM4_3.3V: D1.A, IC3.2 (VO), NT1.1, R1.1, R3.1; also elsewhere on the board
DAC_OUT1: IC2.49 (PA4); also elsewhere on the board
DIN2: IC2.46 (PA3); also elsewhere on the board
DIN3: IC2.150 (PD7); also elsewhere on the board
DOUT2: IC2.148 (PD5); also elsewhere on the board
DOUT3: IC2.149 (PD6); also elsewhere on the board
DSI0_C_N: IC2.107 (DSI_CKN); also elsewhere on the board
DSI0_C_P: IC2.106 (DSI_CKP); also elsewhere on the board
DSI0_D0_N: IC2.104 (DSI_D0N); also elsewhere on the board
DSI0_D0_P: IC2.103 (DSI_D0P); also elsewhere on the board
ENC_A: IC2.122 (PC6); also elsewhere on the board
ENC_B: IC2.123 (PC7); also elsewhere on the board
ENC_SW: IC2.110 (PG2); also elsewhere on the board
ETH_CRS_DV: IC2.52 (PA7); also elsewhere on the board
ETH_MDC: IC2.35 (PC1); also elsewhere on the board
ETH_MDIO: IC2.43 (PA2); also elsewhere on the board
ETH_REF_CLK: IC2.42 (PA1); also elsewhere on the board
ETH_RXD0: IC2.53 (PC4); also elsewhere on the board
ETH_RXD1: IC2.54 (PC5); also elsewhere on the board
ETH_TXD0: IC2.157 (PG13); also elsewhere on the board
ETH_TXD1: IC2.156 (PG12); also elsewhere on the board
ETH_TX_EN: IC2.79 (PB11); also elsewhere on the board
FMC_A0: IC2.18 (PF0); also elsewhere on the board
FMC_A1: IC2.19 (PF1); also elsewhere on the board
FMC_A2: IC2.20 (PF2); also elsewhere on the board
FMC_A3: IC2.21 (PF3); also elsewhere on the board
FMC_A4: IC2.22 (PF4); also elsewhere on the board
FMC_A5: IC2.23 (PF5); also elsewhere on the board
FMC_A6: IC2.59 (PF12); also elsewhere on the board
FMC_A7: IC2.60 (PF13); also elsewhere on the board
FMC_A8: IC2.61 (PF14); also elsewhere on the board
FMC_A9: IC2.62 (PF15); also elsewhere on the board
FMC_A10: IC2.63 (PG0); also elsewhere on the board
FMC_A11: IC2.66 (PG1); also elsewhere on the board
FMC_BA0: IC2.114 (PG4); also elsewhere on the board
FMC_BA1: IC2.115 (PG5); also elsewhere on the board
FMC_D0: IC2.97 (PD14); also elsewhere on the board
FMC_D1: IC2.98 (PD15); also elsewhere on the board
FMC_D2: IC2.143 (PD0); also elsewhere on the board
FMC_D3: IC2.144 (PD1); also elsewhere on the board
FMC_D4: IC2.67 (PE7); also elsewhere on the board
FMC_D5: IC2.68 (PE8); also elsewhere on the board
FMC_D6: IC2.69 (PE9); also elsewhere on the board
FMC_D7: IC2.72 (PE10); also elsewhere on the board
FMC_D8: IC2.73 (PE11); also elsewhere on the board
FMC_D9: IC2.74 (PE12); also elsewhere on the board
FMC_D10: IC2.75 (PE13); also elsewhere on the board
FMC_D11: IC2.76 (PE14); also elsewhere on the board
FMC_D12: IC2.77 (PE15); also elsewhere on the board
FMC_D13: IC2.89 (PD8); also elsewhere on the board
FMC_D14: IC2.90 (PD9); also elsewhere on the board
FMC_D15: IC2.91 (PD10); also elsewhere on the board
FMC_NBL0: IC2.170 (PE0); also elsewhere on the board
FMC_NBL1: IC2.171 (PE1); also elsewhere on the board
FMC_SDCKE0: IC2.37 (PC3_C); also elsewhere on the board
FMC_SDCLK: IC2.118 (PG8); also elsewhere on the board
FMC_SDNCAS: IC2.161 (PG15); also elsewhere on the board
FMC_SDNE0: IC2.36 (PC2_C); also elsewhere on the board
FMC_SDNRAS: IC2.58 (PF11); also elsewhere on the board
FMC_SDNWE: IC2.34 (PC0); also elsewhere on the board
GND: C1.1, C2.2, C5.2, C6.2, C8.-, C9.2, C11.1, C12.2, C13.2, C14.2, C15.2, C16.2, C17.2, C18.2, C19.2, C20.2, C21.1, C22.1, C23.2, C24.2, C25.2, C26.2, C27.2, C28.2, C29.1, C30.-, C31.2, C32.2, C35.1, C36.1, C37.1, C38.2, C39.1, C40.2, C41.2, C42.2, C43.2, C44.2, H1.1, H2.1, H3.1, H4.1, IC2.6 (VSS.6), IC2.12 (VSS.12), IC2.14 (VSSSMPS), IC2.24 (VSS.24), IC2.45 (VSS.45), IC2.47 (VSS.47), IC2.64 (VSS.64), IC2.70 (VSS.70), IC2.81 (VSS.81), IC2.83 (VSS.83), IC2.93 (VSS.93), IC2.100 (VSS.100), IC2.105 (VSSDSI.105), IC2.109 (VSSDSI.109), IC2.112 (VSS.112), IC2.119 (VSS.119), IC2.134 (VSS.134), IC2.137 (VSS.137), IC2.151 (VSS.151), IC2.159 (VSS.159), IC2.173 (VSS.173), IC3.1 (GND), JP1.NC, NT2.1, R11.1, XTAL1.2 (GND), XTAL1.4 (GND); also elsewhere on the board
GPIO4: IC2.146 (PD3); also elsewhere on the board
GPIO6: IC2.127 (PA8); also elsewhere on the board
GPIO7: IC2.94 (PD11); also elsewhere on the board
GPIO8: IC2.140 (PC10); also elsewhere on the board
GPIO9: IC2.87 (PB14); also elsewhere on the board
GPIO10: IC2.88 (PB15); also elsewhere on the board
GPIO11: IC2.86 (PB13); also elsewhere on the board
GPIO12: IC2.29 (PF9); also elsewhere on the board
GPIO13: IC2.163 (PB4); also elsewhere on the board
GPIO14: IC2.164 (PB5); also elsewhere on the board
GPIO15: IC2.155 (PG11); also elsewhere on the board
GPIO17: IC2.2 (PE3); also elsewhere on the board
GPIO18: IC2.3 (PE4); also elsewhere on the board
GPIO19: IC2.4 (PE5); also elsewhere on the board
GPIO20: IC2.5 (PE6); also elsewhere on the board
GPIO21: IC2.1 (PE2); also elsewhere on the board
GPIO22: IC2.139 (PA15); also elsewhere on the board
GPIO23: IC2.116 (PG6); also elsewhere on the board
GPIO26: IC2.51 (PA6); also elsewhere on the board
GPIO27: IC2.111 (PG3); also elsewhere on the board
HDMI0_CLK_P: IC2.128 (PA9); also elsewhere on the board
HDMI0_SCL: C30.+, R12.1; also elsewhere on the board
HDMI0_TX0_N: IC2.141 (PC11); also elsewhere on the board
HDMI0_TX0_P: IC2.147 (PD4); also elsewhere on the board
I2C1_SCL: IC2.165 (PB6), R1.2; also elsewhere on the board
I2C1_SDA: IC2.166 (PB7), R3.2; also elsewhere on the board
ID_SC: IC2.168 (PB8); also elsewhere on the board
ID_SD: IC2.41 (PA0); also elsewhere on the board
RCC_MCO_2: IC2.125 (PC9); also elsewhere on the board
SDMMC1_CK: IC2.142 (PC12); also elsewhere on the board
SDMMC1_CMD: IC2.145 (PD2); also elsewhere on the board
SDMMC1_D0: IC2.124 (PC8); also elsewhere on the board
SD_DETECT: IC2.117 (PG7); also elsewhere on the board
SYS_JTCK-SWCLK: IC2.138 (PA14); also elsewhere on the board
SYS_JTDO-SWO: IC2.162 (PB3); also elsewhere on the board
SYS_JTMS-SWDIO: IC2.132 (PA13); also elsewhere on the board
USB_OTG_HS_D_N: IC2.130 (PA11); also elsewhere on the board
USB_OTG_HS_D_P: IC2.131 (PA12); also elsewhere on the board
USB_OTG_ID: IC2.129 (PA10); also elsewhere on the board
nEXTRST: C29.2, IC2.33 (NRST); also elsewhere on the board

Notes on the sheet:
32-bit dual core MCU
16 MHz
VFBSMPS
Load capacitance: 6 pF
Place C40 near L4
SD_DETECT
Place near the VCAP pins
Place L4 as close as possible to VLXSMPS pin
32.768 kHz
IMPORTANT: For Y1, XTAL1 PCB layout consult ST AN2867 section 7.2

Notices in the files:
EEZ_BB3_CM4_H7/ulx4m.kicad_pcb:
License: CERN-OHL-S v2
EEZ_DIB_MCU_r3B4/EEZ_DIB_MCU_r3B4.kicad_pcb:
This hardware is licensed under CERN-OHL-S v2 or later.
