# Repository intergalaktik/bb3-cm4 (continued)

## KiCad design EEZ_BB3_CM4_R1B0/EEZ_DIB_BP3C_r3B3.kicad_pcb (continued)

Board: 4 copper layers, 110.0 x 90.0 mm, 63 parts (0 on the bottom side), 70 nets.

Other parts of the board:
EEZ_SIGNATURE0: SIGNATURESMALL; SIGNATURE_5MM
U$2: RECYCLE_BIN1_8
U$4: ESD_SYMBOL
U$5: PB_SMALL

## KiCad design EEZ_BB3_CM4_H7/ulx4m.kicad_pcb

Board: 6 copper layers, 55.1 x 40.0 mm, 12 parts (5 on the bottom side), 10 nets, no tracks yet.

Parts:
FI1, FI2, FI3, FI4, FI5, FI6: Fi; Fiducial_0.5mm_Mask1mm
H1, H2, H3, H4: HOLE; MountingHole_3.2mm_M3_ISO14580_Pad
J1, J2: DF40C-100DP-0.4V(51); HRS_DF40C-100DP-0.4V(51)

Connections:
+5V: J1.77, J1.79, J1.81, J1.83, J1.85, J1.87
CM4_1.8V: J1.88, J1.90
CM4_3.3V: J1.84, J1.86
GND: H1.1, H2.1, H3.1, H4.1, J1.1, J1.2, J1.7, J1.8, J1.13, J1.14, J1.22, J1.23, J1.32, J1.33, J1.42, J1.43, J1.52, J1.53, J1.59, J1.60, J1.65, J1.66, J1.71, J1.74, J1.98, J2.7, J2.8, J2.13, J2.14, J2.19, J2.20, J2.25, J2.26, J2.31, J2.32, J2.37, J2.38, J2.44, J2.50, J2.55, J2.56, J2.61, J2.62, J2.67, J2.68, J2.73, J2.74, J2.79, J2.80, J2.85, J2.86, J2.91, J2.92, J2.97, J2.98
GPIO2: J1.58, J1.69
GPIO3: J1.56, J1.67
GPIO4: J1.54, J1.63
GPIO14: J1.55, J1.61
GPIO15: J1.51, J1.57
GPIO27: J1.48, J1.62

## Code that names these connections

File EEZ_BB3_CM4_H7/IOC/H757.ioc (part):

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Mcu.Name=STM32H757IITx
Mcu.Package=LQFP176
Mcu.UserName=STM32H757IITx
PA0.GPIOParameters=PinAttribute
PA0.Mode=Asynchronous
PA0.PinAttribute=CortexM7
PA0.Signal=UART4_TX
PA1.GPIOParameters=PinAttribute
PA1.Mode=RMII
PA1.PinAttribute=CortexM7
PA1.Signal=ETH_REF_CLK
PA10.GPIOParameters=PinAttribute
PA10.Mode=OTG/Dual_Role_Device
PA10.PinAttribute=CortexM7
PA10.Signal=USB_OTG_FS_ID
PA11.GPIOParameters=PinAttribute
PA11.Mode=OTG/Dual_Role_Device
PA11.PinAttribute=CortexM7
PA11.Signal=USB_OTG_FS_DM
PA12.GPIOParameters=PinAttribute
PA12.Mode=OTG/Dual_Role_Device
PA12.PinAttribute=CortexM7
PA12.Signal=USB_OTG_FS_DP
PA13\ (JTMS/SWDIO).GPIOParameters=PinAttribute
PA13\ (JTMS/SWDIO).Mode=Trace_Asynchronous_SW
PA13\ (JTMS/SWDIO).PinAttribute=CortexM7
PA13\ (JTMS/SWDIO).Signal=DEBUG_JTMS-SWDIO
PA14\ (JTCK/SWCLK).GPIOParameters=PinAttribute
PA14\ (JTCK/SWCLK).Mode=Trace_Asynchronous_SW
PA14\ (JTCK/SWCLK).PinAttribute=CortexM7
PA14\ (JTCK/SWCLK).Signal=DEBUG_JTCK-SWCLK
PA15\ (JTDI).GPIOParameters=GPIO_Label,PinAttribute
PA15\ (JTDI).GPIO_Label=SPI1_IRQ
PA15\ (JTDI).PinAttribute=Free
PA15\ (JTDI).Signal=GPIO_Input
PA2.GPIOParameters=PinAttribute
PA2.Mode=RMII
PA2.PinAttribute=CortexM7
PA2.Signal=ETH_MDIO
PA3.GPIOParameters=GPIO_Label,PinAttribute
PA3.GPIO_Label=DIN2
PA3.Mode=Asynchronous
PA3.PinAttribute=CortexM7
PA3.Signal=USART2_RX
PA4.GPIOParameters=GPIO_Label,PinAttribute
PA4.GPIO_Label=DAC_OUT1
PA4.PinAttribute=CortexM7
PA4.Signal=COMP_DAC11_group
PA5.GPIOParameters=GPIO_Label,PinAttribute
PA5.GPIO_Label=AUDIO_OUT
PA5.PinAttribute=Free
PA5.Signal=GPIO_Output
PA6.GPIOParameters=GPIO_Label,PinAttribute
PA6.GPIO_Label=SPI1_CSB
PA6.PinAttribute=Free
PA6.Signal=GPIO_Output
PA7.GPIOParameters=PinAttribute
PA7.Mode=RMII
PA7.PinAttribute=CortexM7
PA7.Signal=ETH_CRS_DV
PA8.GPIOParameters=GPIO_Label,PinAttribute
PA8.GPIO_Label=SPI2_IRQ
PA8.PinAttribute=Free
PA8.Signal=GPIO_Input
PA9.GPIOParameters=PinAttribute
PA9.Mode=Activate_VBUS
PA9.PinAttribute=CortexM7
PA9.Signal=USB_OTG_FS_VBUS
PB0.GPIOParameters=GPIO_Label,PinAttribute
PB0.GPIO_Label=PWR_SSTART
PB0.PinAttribute=Free
PB0.Signal=GPIO_Output
PB1.GPIOParameters=GPIO_Label,PinAttribute
PB1.GPIO_Label=PWR_DIRECT
PB1.PinAttribute=Free
PB1.Signal=GPIO_Output
PB11.GPIOParameters=PinAttribute
PB11.Mode=RMII
PB11.PinAttribute=CortexM7
PB11.Signal=ETH_TX_EN
PB12.GPIOParameters=GPIO_Label,PinAttribute
PB12.GPIO_Label=RTC_REF
PB12.PinAttribute=Free
PB12.Signal=GPIO_Input
PB13.GPIOParameters=PinAttribute
PB13.Mode=Full_Duplex_Master
PB13.PinAttribute=CortexM7
PB13.Signal=SPI2_SCK
PB14.GPIOParameters=PinAttribute
PB14.Mode=Full_Duplex_Master
PB14.PinAttribute=CortexM7
PB14.Signal=SPI2_MISO
PB15.GPIOParameters=PinAttribute
PB15.Mode=Full_Duplex_Master
PB15.PinAttribute=CortexM7
PB15.Signal=SPI2_MOSI
PB2.GPIOParameters=GPIO_Label,PinAttribute
PB2.GPIO_Label=_FAULT
PB2.PinAttribute=Free
PB2.Signal=GPIO_Output
PB3\ (JTDO/TRACESWO).GPIOParameters=PinAttribute
PB3\ (JTDO/TRACESWO).Mode=Trace_Asynchronous_SW
PB3\ (JTDO/TRACESWO).PinAttribute=CortexM7
PB3\ (JTDO/TRACESWO).Signal=DEBUG_JTDO-SWO
PB4\ (NJTRST).GPIOParameters=PinAttribute
PB4\ (NJTRST).Mode=Full_Duplex_Master
PB4\ (NJTRST).PinAttribute=CortexM7
PB4\ (NJTRST).Signal=SPI1_MISO
PB5.GPIOParameters=PinAttribute
PB5.Mode=Full_Duplex_Master
PB5.PinAttribute=CortexM7
PB5.Signal=SPI1_MOSI
PB6.GPIOParameters=PinAttribute
PB6.Mode=I2C
PB6.PinAttribute=CortexM7
PB6.Signal=I2C1_SCL
PB7.GPIOParameters=PinAttribute
PB7.Mode=I2C
PB7.PinAttribute=CortexM7
PB7.Signal=I2C1_SDA
PB8.GPIOParameters=GPIO_Label,PinAttribute
PB8.GPIO_Label=UART_RX/DIN1
PB8.Mode=Asynchronous
PB8.PinAttribute=CortexM7
PB8.Signal=UART4_RX
PC0.GPIOParameters=PinAttribute
PC0.PinAttribute=CortexM7
PC0.Signal=FMC_SDNWE
PC1.GPIOParameters=PinAttribute
PC1.Mode=RMII
PC1.PinAttribute=CortexM7
PC1.Signal=ETH_MDC
PC10.GPIOParameters=GPIO_Label,PinAttribute
PC10.GPIO_Label=SPI2_CSA
PC10.PinAttribute=Free
PC10.Signal=GPIO_Output
PC11.GPIOParameters=GPIO_Label,PinAttribute
PC11.GPIO_Label=USB_OTG_FS_OC
PC11.PinAttribute=Free
PC11.Signal=GPIO_Input
PC12.GPIOParameters=PinAttribute
PC12.Mode=SD_1_bit
PC12.PinAttribute=CortexM7
PC12.Signal=SDMMC1_CK
PC13.GPIOParameters=GPIO_Label,PinAttribute
PC13.GPIO_Label=WDG
PC13.PinAttribute=Free
PC13.Signal=GPIO_Output
PC14-OSC32_IN\ (OSC32_IN).GPIOParameters=PinAttribute
PC14-OSC32_IN\ (OSC32_IN).Mode=LSE-External-Oscillator
PC14-OSC32_IN\ (OSC32_IN).PinAttribute=Free
PC14-OSC32_IN\ (OSC32_IN).Signal=RCC_OSC32_IN
PC15-OSC32_OUT\ (OSC32_OUT).GPIOParameters=PinAttribute
PC15-OSC32_OUT\ (OSC32_OUT).Mode=LSE-External-Oscillator
PC15-OSC32_OUT\ (OSC32_OUT).PinAttribute=Free
PC15-OSC32_OUT\ (OSC32_OUT).Signal=RCC_OSC32_OUT
PC2_C.GPIOParameters=PinAttribute
PC2_C.Mode=SdramChipSelect1_1
PC2_C.PinAttribute=CortexM7
PC2_C.Signal=FMC_SDNE0
PC3_C.GPIOParameters=PinAttribute
PC3_C.Mode=SdramChipSelect1_1
PC3_C.PinAttribute=CortexM7
PC3_C.Signal=FMC_SDCKE0
PC4.GPIOParameters=PinAttribute
PC4.Mode=RMII
PC4.PinAttribute=CortexM7
PC4.Signal=ETH_RXD0
PC5.GPIOParameters=PinAttribute
PC5.Mode=RMII
PC5.PinAttribute=CortexM7
PC5.Signal=ETH_RXD1
PC6.GPIOParameters=GPIO_Label,PinAttribute
PC6.GPIO_Label=ENC_A
PC6.PinAttribute=Free
PC6.Signal=GPIO_Input
PC7.GPIOParameters=GPIO_Label,PinAttribute
PC7.GPIO_Label=ENC_B
PC7.PinAttribute=Free
PC7.Signal=GPIO_Input
PC8.GPIOParameters=PinAttribute
PC8.Mode=SD_1_bit
PC8.PinAttribute=CortexM7
PC8.Signal=SDMMC1_D0
PC9.GPIOParameters=PinAttribute
PC9.Mode=Clock-out-2
PC9.PinAttribute=Free
PC9.Signal=RCC_MCO_2
PD0.GPIOParameters=PinAttribute
PD0.PinAttribute=CortexM7
PD0.Signal=FMC_D2_DA2
PD1.GPIOParameters=PinAttribute
PD1.PinAttribute=CortexM7
PD1.Signal=FMC_D3_DA3
PD10.GPIOParameters=PinAttribute
PD10.PinAttribute=CortexM7
PD10.Signal=FMC_D15_DA15
PD11.GPIOParameters=GPIO_Label,PinAttribute
PD11.GPIO_Label=SPI2_CSB
PD11.PinAttribute=Free
PD11.Signal=GPIO_Output
PD12.GPIOParameters=GPIO_Label,PinAttribute
PD12.GPIO_Label=TFT_BRIGHTNESS
PD12.PinAttribute=CortexM7
PD12.Signal=S_TIM4_CH1
PD13.GPIOParameters=GPIO_Label,PinAttribute
PD13.GPIO_Label=OE_SYNC
PD13.PinAttribute=Free
PD13.Signal=GPIO_Output
PD14.GPIOParameters=PinAttribute
PD14.PinAttribute=CortexM7
PD14.Signal=FMC_D0_DA0
PD15.GPIOParameters=PinAttribute
PD15.PinAttribute=CortexM7
PD15.Signal=FMC_D1_DA1
PD2.GPIOParameters=PinAttribute
PD2.Mode=SD_1_bit
PD2.PinAttribute=CortexM7
PD2.Signal=SDMMC1_CMD
PD3.GPIOParameters=GPIO_Label,PinAttribute
PD3.GPIO_Label=IRQ_TOUCH
PD3.PinAttribute=Free
PD3.Signal=GPIO_Input
PD4.GPIOParameters=GPIO_Label,PinAttribute
PD4.GPIO_Label=USB_OTG_FS_PSO
PD4.PinAttribute=Free
PD4.Signal=GPIO_Output
PD5.GPIOParameters=GPIO_Label,PinAttribute
PD5.GPIO_Label=DOUT2
PD5.Mode=Asynchronous
PD5.PinAttribute=CortexM7
PD5.Signal=USART2_TX
PD6.GPIOParameters=GPIO_Label,PinAttribute
PD6.GPIO_Label=DOUT3
PD6.PinAttribute=Free
PD6.Signal=GPIO_Output
PD7.GPIOParameters=GPIO_Label,PinAttribute
PD7.GPIO_Label=DIN3
PD7.PinAttribute=Free
PD7.Signal=GPIO_Input
PD8.GPIOParameters=PinAttribute
PD8.PinAttribute=CortexM7
PD8.Signal=FMC_D13_DA13
PD9.GPIOParameters=PinAttribute
PD9.PinAttribute=CortexM7
PD9.Signal=FMC_D14_DA14
PE0.GPIOParameters=PinAttribute
PE0.PinAttribute=CortexM7
PE0.Signal=FMC_NBL0
PE1.GPIOParameters=PinAttribute
PE1.PinAttribute=CortexM7
PE1.Signal=FMC_NBL1
PE10.GPIOParameters=PinAttribute
PE10.PinAttribute=CortexM7
PE10.Signal=FMC_D7_DA7
PE11.GPIOParameters=PinAttribute
PE11.PinAttribute=CortexM7
PE11.Signal=FMC_D8_DA8
PE12.GPIOParameters=PinAttribute
PE12.PinAttribute=CortexM7
PE12.Signal=FMC_D9_DA9
PE13.GPIOParameters=PinAttribute
PE13.PinAttribute=CortexM7
PE13.Signal=FMC_D10_DA10
PE14.GPIOParameters=PinAttribute
PE14.PinAttribute=CortexM7
PE14.Signal=FMC_D11_DA11
PE15.GPIOParameters=PinAttribute
PE15.PinAttribute=CortexM7
PE15.Signal=FMC_D12_DA12
PE2.GPIOParameters=PinAttribute
PE2.Mode=Full_Duplex_Master
PE2.PinAttribute=CortexM7
PE2.Signal=SPI4_SCK
PE3.GPIOParameters=GPIO_Label,PinAttribute
PE3.GPIO_Label=SPI4_CSB
PE3.PinAttribute=Free
PE3.Signal=GPIO_Output
PE4.GPIOParameters=GPIO_Label,PinAttribute
PE4.GPIO_Label=SPI4_CSA
PE4.PinAttribute=Free
PE4.Signal=GPIO_Output
PE5.GPIOParameters=PinAttribute
PE5.Mode=Full_Duplex_Master
PE5.PinAttribute=CortexM7
PE5.Signal=SPI4_MISO
PE6.GPIOParameters=PinAttribute
PE6.Mode=Full_Duplex_Master
PE6.PinAttribute=CortexM7
PE6.Signal=SPI4_MOSI
PE7.GPIOParameters=PinAttribute
PE7.PinAttribute=CortexM7
PE7.Signal=FMC_D4_DA4
PE8.GPIOParameters=PinAttribute
PE8.PinAttribute=CortexM7
PE8.Signal=FMC_D5_DA5
PE9.GPIOParameters=PinAttribute
PE9.PinAttribute=CortexM7
PE9.Signal=FMC_D6_DA6
PF0.GPIOParameters=PinAttribute
PF0.PinAttribute=CortexM7
PF0.Signal=FMC_A0
PF1.GPIOParameters=PinAttribute
PF1.PinAttribute=CortexM7
PF1.Signal=FMC_A1
PF11.GPIOParameters=PinAttribute
PF11.PinAttribute=CortexM7
PF11.Signal=FMC_SDNRAS
PF12.GPIOParameters=PinAttribute
PF12.PinAttribute=CortexM7
PF12.Signal=FMC_A6
PF13.GPIOParameters=PinAttribute
PF13.PinAttribute=CortexM7
PF13.Signal=FMC_A7
PF14.GPIOParameters=PinAttribute
PF14.PinAttribute=CortexM7

## Commit log

2023-04-12 Initial import
2023-04-12 Clearing schematics and PCB errors from importing
2023-04-15 Converting BP3C board
2023-04-15 Schematics update
2023-04-25 Boards are now combined, but not synced with schematics
2023-04-25 Importing BP3
2023-04-25 Cleaning all errors
2023-05-08 Switching MCU to KiCad 7 - moving MCU and SDRAM from board
2023-05-08 Removing Backups, addin new version
2023-05-08 Adding connectors, grouping parts, removing most of the routing
2023-06-06 Splitting SoM and MCU board
2023-06-07 Adding ICN6211
2023-06-08 Moving footprints - change 0804 to 0603
2023-06-08 Removing non used components in schematic
2023-06-26 Updating 3D models
2023-06-26 Adding License
2023-06-26 Adding connections to Ethernet connector
2023-06-26 Adding DSI connector
2023-06-27 More routing
2023-06-27 Routing
2023-06-27 Routing almost finished
2023-06-28 Update pictures and 3D models
2023-06-28 Changing name in license file
2023-06-28 Updating License informations
2023-07-12 Adding temperary PCIe connector - adding logos
2023-07-13 Adding missing 3D models, refreshing pictures
2023-12-09 Adding partially routed H7
2024-01-02 Adding pinout table
2024-01-02 Adding GPIO connections
2024-01-04 Routing adding ioc
2024-01-04 Routing - new ioc
2024-01-09 Routing - fixing errors
2024-01-09 Fixing errors - adding README
2024-01-09 Cleanup
2024-01-11 3D models path update
2024-04-05 Fix #6
2024-04-09 Updating pinout
2024-04-11 Adding USB
2024-04-11 Removing picture
2024-04-11 Moving components - moving EEZ logo to top
2024-04-11 Removing logo from back
2024-04-11 Adding production files
2024-06-30 Adding Paula work
2024-07-01 Adding blender file
2024-07-02 Adding animation
2024-07-02 Removing avi
2024-07-02 Adding README
