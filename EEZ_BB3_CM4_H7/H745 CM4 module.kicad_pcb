# Repository intergalaktik/bb3-cm4 (continued)

## KiCad design EEZ_DIB_MCU_r3B4/EEZ_DIB_MCU_r3B4.kicad_pcb (continued)

Parts:
C1: EEEFK1V220R; Fuse_0805_2012Metric
C2: 2u2; C_0603_1608Metric
C3, C5, C7, C8: 10n; C_0603_1608Metric
C4, C6, C9: 100n; C_0603_1608Metric
C27: 4u7; EC1206
F1: 500mA; Fuse_0805_2012Metric
FM1, FM2, FM3, FM4, FM5, FM6, FM7, FM8: FIDUCIAL
IC1: TPD4E001DRLR; DRL6
IC2: 74AUP1G74DC.125; DCU8
IC3: CD74HC4050PWR; PW16
IC4: TPS2051BDBVR; DBV5
R1, R4, R5, R7, R8, R9: 4K7; R_0603_1608Metric
R2, R3, R11, R41: 10K; R_0603_1608Metric
R6, R10: 1K; R_0603_1608Metric
R40: 0R; R_0603_1608Metric
SW1: TL1100CF160Q; TL1100C
SW2: PEC16-2215F-S0024; PEC16-2215F
X1: DS1024-2*20R0; ZL263-40DG
X2: DS1013-16SSIB1; IDC-16PIN
X3: 691322110005; MC1,5_5-G-3,5

Connections:
5V_SWITCH_OUT: F1.2, IC4.3 (~OC)
+5V: C4.1, IC1.6 (VCC), IC4.5 (IN), X1.35 (1), X1.36 (1), X2.5 (1), X2.6 (1); also elsewhere on the board
+12V: C2.1, X1.37 (1), X1.38 (1), X2.3 (1), X2.4 (1); also elsewhere on the board
+VAUX: X2.10 (1)
+VAUX_OUT: X1.5 (1)
BOOT0: IC2.3 (~Q); also elsewhere on the board
DIN2: R10.2; also elsewhere on the board
DOUT2: IC3.7 (I), IC3.9 (I), IC4.4 (EN), R41.2; also elsewhere on the board
ENC_A: C7.2, R2.1; also elsewhere on the board
ENC_B: C8.1, R11.1; also elsewhere on the board
ENC_SW: C5.2, SW2.E (2); also elsewhere on the board
I2C1_SCL: X1.12 (1), X2.13 (1); also elsewhere on the board
I2C1_SDA: X1.14 (1), X2.14 (1); also elsewhere on the board
unnamed: IC1.1 (IO1), R4.2, R5.1
unnamed: IC1.2 (IO2), R8.2, R9.1
unnamed: IC1.4 (IO3), IC3.4 (O), IC3.12 (O), X3.4 (1)
unnamed: F1.1, IC1.5 (IO4), R40.1, X3.5 (1)
unnamed: IC3.6 (O), IC3.10 (O), R40.2
unnamed: IC3.14 (I), R5.2
unnamed: IC3.15 (O), R6.1
unnamed: IC3.3 (I), R9.2
unnamed: IC3.2 (O), R10.1
unnamed: C27.+, IC4.1 (OUT)
unnamed: R1.2, R2.2, SW2.A
unnamed: R4.1, X3.1
unnamed: R7.2, R11.2, SW2.B
unnamed: R8.1, X3.2 (1)
OE_SYNC: X1.10 (1); also elsewhere on the board
PE: X2.1; also elsewhere on the board
PWR_DIRECT: X2.12 (1); also elsewhere on the board
PWR_SSTART: X2.11 (1); also elsewhere on the board
RTC_REF: X2.2 (1); also elsewhere on the board
SPI2_CLK: X1.32 (1); also elsewhere on the board
SPI2_CSA: X1.28 (1); also elsewhere on the board
SPI2_CSB: X1.27 (1); also elsewhere on the board
SPI2_IRQ: X1.25 (1); also elsewhere on the board
SPI2_MISO: X1.31 (1); also elsewhere on the board
SPI2_MOSI: X1.33 (1); also elsewhere on the board
SPI4_CLK: X1.23 (1); also elsewhere on the board
SPI4_CSA: X1.22 (1); also elsewhere on the board
SPI4_CSB: X1.21 (1); also elsewhere on the board
SPI4_IRQ: X1.19 (1); also elsewhere on the board
SPI4_MISO: X1.24 (1); also elsewhere on the board
SPI4_MOSI: X1.26 (1); also elsewhere on the board
SPI5_CLK: X1.17 (1); also elsewhere on the board
SPI5_CSA: X1.11 (1); also elsewhere on the board
SPI5_CSB: X1.13 (1); also elsewhere on the board
SPI5_IRQ: X1.9 (1); also elsewhere on the board
SPI5_MISO: X1.18 (1); also elsewhere on the board
SPI5_MOSI: X1.20 (1); also elsewhere on the board
USER_SW: C3.2, IC2.1 (CLK), R3.2, SW1.1; also elsewhere on the board
~FAULT: X1.8 (1), X2.15 (1); also elsewhere on the board
~RESET: X1.6 (1); also elsewhere on the board

Notes on the sheet:
UART_TX/DOUT1 4
SSCL (optional) 13
20 SPI3_MOSI
Output connector (3 x SPI modules)
8 NFAULT
SPI1_CSB 27
DOUT2 5
4 UART_TX
User / Boot0 switch
38 +12V
Gnd 39
+5V 5
5-pin I/O connector
32 SPI1_SCLK
40 Gnd
SPI1_MISO 31
16-pin DIB AUX PS socket
I/O connectors, User SW, Encoder, Digital I/O
~{FAULT} 15
12 PWR_DIRECT
36 +5V
+Vaux 5
14 I2C_SDA
PWR_SSTART 11
SPI1_MOSI 33
8 Gnd
10 +VAUX
+5V 35
SPI2_IRQ 19
+12V 37
28 SPI1_CSA
26 SPI2_MOSI
10 OE_SYNC
22 SPI2_CSA
Tant.
SPI2_CSB 21
Gnd 29
Input connector (power, soft start, fan controller)
24 SPI2_MISO
14 SSDA (optional)

Parts:
C20, C22, C24: 10nF; C_0603_1608Metric
C21, C23, C25: 1uF; C_0603_1608Metric
C38, C39, C40, C41, C42, C43, C44, C45: 22nF; C_0603_1608Metric
D30: 3.6V; D_SOD-323_HandSoldering
GPDI1: GPDI-D; CONN-10029449-111RLF; MPN 10029449-111RLF; Mouser 649-10029449-111RLF
J4: Conn_01x22_Socket; Hirose_FH12-22S-0.5SH_1x22-1MP_P0.50mm_Horizontal
J5: USB1086-GF-B_REVA; GCT_USB1086-GF-B_REVA; PARTREV A
J6: 1586041-6; TE_1586041-6
Module1: ComputeModule4-CM4; Raspberry-Pi-4-Compute-Module
R12, R13, R14, R15, R16, R17, R42: 0; R_0603_1608Metric
R19, R21: 4.7K; R_0603_1608Metric
R61, R67: 549; R_0603_1608Metric
U1: ICN6211; QFN-48-1EP_6x6mm_P0.4mm_EP4.2x4.2mm

Connections:
+5V: GPDI1.18 (+5V), J5.1 (VBUS); also elsewhere on the board
+12V: J6.1, J6.5; also elsewhere on the board
/CM4_IO_fast/DSI_D2+: U1.20 (DSI_D2+)
/CM4_IO_fast/DSI_D2-: U1.21 (DSI_D2-)
/CM4_IO_fast/DSI_D3+: U1.22 (DSI_D3+)
/CM4_IO_fast/DSI_D3-: U1.23 (DSI_D3-)
/CM4_IO_fast/EN: U1.11 (EN)
/CM4_IO_fast/GPDI_CEC: GPDI1.13 (CEC); also elsewhere on the board
/CM4_IO_fast/GPDI_CLK+: GPDI1.10 (CLK+); also elsewhere on the board
/CM4_IO_fast/GPDI_CLK-: GPDI1.12 (CLK-); also elsewhere on the board
/CM4_IO_fast/GPDI_D0+: GPDI1.7 (D0+); also elsewhere on the board
/CM4_IO_fast/GPDI_D0-: GPDI1.9 (D0-); also elsewhere on the board
/CM4_IO_fast/GPDI_D2+: GPDI1.1 (D2+); also elsewhere on the board
/CM4_IO_fast/GPDI_D2-: GPDI1.3 (D2-); also elsewhere on the board
/CM4_IO_fast/GPDI_HPD: GPDI1.19 (HPD); also elsewhere on the board
/CM4_IO_fast/REF_CLK: U1.13 (REF_CLK)
CAM0_C_N: Module1.140 (CAM0_C_N), R16.1
CAM0_C_P: Module1.142 (CAM0_C_P), R17.1
CAM0_D0_N: Module1.128 (CAM0_D0_N), R12.1
CAM0_D0_P: Module1.130 (CAM0_D0_P), R13.1
CAM0_D1_N: Module1.134 (CAM0_D1_N), R14.1
CAM0_D1_P: Module1.136 (CAM0_D1_P), R15.1
DSIHOST_CKN: J4.15, Module1.169 (DSI0_C_N), U1.19 (DSI_CLK-)
DSIHOST_CKP: J4.14, Module1.171 (DSI0_C_P), U1.18 (DSI_CLK+)
DSIHOST_D0N: J4.21, Module1.157 (DSI0_D0_N), U1.15 (DSI_D0-)
DSIHOST_D0P: J4.20, Module1.159 (DSI0_D0_P), U1.14 (DSI_D0+)
DSIHOST_D1N: J4.18, Module1.163 (DSI0_D1_N), U1.17 (DSI_D1-)
DSIHOST_D1P: J4.17, Module1.165 (DSI0_D1_P), U1.16 (DSI_D1+)
GPDI0_CEC: Module1.151 (HDMI0_CEC); also elsewhere on the board
GPDI0_CLK_N: Module1.190 (HDMI0_CLK_N); also elsewhere on the board
GPDI0_CLK_P: Module1.188 (HDMI0_CLK_P); also elsewhere on the board
GPDI0_HOTPLUG: Module1.153 (HDMI0_HOTPLUG); also elsewhere on the board
GPDI0_SCL: GPDI1.15 (GPDI_SCL), Module1.200 (HDMI0_SCL)
GPDI0_SDA: GPDI1.16 (GPDI_SDA), Module1.199 (HDMI0_SDA)
GPDI0_TX0_N: Module1.184 (HDMI0_TX0_N); also elsewhere on the board
GPDI0_TX0_P: Module1.182 (HDMI0_TX0_P); also elsewhere on the board
GPDI0_TX2_N: Module1.172 (HDMI0_TX2_N); also elsewhere on the board
GPDI0_TX2_P: Module1.170 (HDMI0_TX2_P); also elsewhere on the board
I2C1_SCL: J4.3, R19.1, U1.9 (SCL); also elsewhere on the board
I2C1_SDA: J4.2, R21.2, U1.10 (SDA); also elsewhere on the board
LTDC_B0: U1.47 (DATA16); also elsewhere on the board
LTDC_B1: U1.48 (DATA17); also elsewhere on the board
LTDC_B2: U1.1 (DATA18); also elsewhere on the board
LTDC_B3: U1.2 (DATA19); also elsewhere on the board
LTDC_B4: U1.4 (DATA20); also elsewhere on the board
LTDC_B5: U1.5 (DATA21); also elsewhere on the board
LTDC_B6: U1.6 (DATA22); also elsewhere on the board
LTDC_B7: U1.7 (DATA23); also elsewhere on the board
LTDC_CLK: U1.25 (PCLK); also elsewhere on the board
LTDC_DE: U1.28 (DE); also elsewhere on the board
LTDC_G0: U1.38 (DATA8); also elsewhere on the board
LTDC_G1: U1.39 (DATA9); also elsewhere on the board
LTDC_G2: U1.41 (DATA10); also elsewhere on the board
LTDC_G3: U1.42 (DATA11); also elsewhere on the board
LTDC_G4: U1.43 (DATA12); also elsewhere on the board
LTDC_G5: U1.44 (DATA13); also elsewhere on the board
LTDC_G6: U1.45 (DATA14); also elsewhere on the board
LTDC_G7: U1.46 (DATA15); also elsewhere on the board
LTDC_HSYNC: U1.26 (HSYNC); also elsewhere on the board
LTDC_R0: U1.29 (DATA0); also elsewhere on the board
LTDC_R1: U1.30 (DATA1); also elsewhere on the board
LTDC_R2: U1.31 (DATA2); also elsewhere on the board
LTDC_R3: U1.32 (DATA3); also elsewhere on the board
LTDC_R4: U1.33 (DATA4); also elsewhere on the board
LTDC_R5: U1.34 (DATA5); also elsewhere on the board
LTDC_R6: U1.36 (DATA6); also elsewhere on the board
LTDC_R7: U1.37 (DATA7); also elsewhere on the board
LTDC_VSYNC: U1.27 (VSYNC); also elsewhere on the board
unnamed: J5.S1 (SHIELD), J5.S2 (SHIELD), R42.2
unnamed: C24.2, C25.2, U1.40 (VCORE)
OE_SYNC: R13.2; also elsewhere on the board
PCIe_CLK_N: J5.2 (D-), Module1.112 (PCIe_CLK_N)
PCIe_CLK_P: J5.3 (D+), Module1.110 (PCIe_CLK_P)
PCIe_CLK_nREQ: Module1.102 (PCIe_CLK_nREQ)
PCIe_RX_N: J5.5 (STDA_SSRX-), Module1.118 (PCIe_RX_N)
PCIe_RX_P: J5.6 (STDA_SSRX+), Module1.116 (PCIe_RX_P)
PCIe_TX_N: J5.8 (STDA_SSTX-), Module1.124 (PCIe_TX_N)
PCIe_TX_P: J5.9 (STDA_SSTX+), Module1.122 (PCIe_TX_P)
PCIe_nRST: Module1.109 (PCIe_nRST)
PWR_DIRECT: R15.2; also elsewhere on the board
PWR_SSTART: R14.2; also elsewhere on the board
RTC_REF: R16.2; also elsewhere on the board
TFT_BRIGHTNESS: R12.2; also elsewhere on the board
USB_OTG_FS_D_N: Module1.103 (USB2_N); also elsewhere on the board
USB_OTG_FS_D_P: Module1.105 (USB2_P); also elsewhere on the board
USB_OTG_FS_ID: Module1.101 (USB_OTG_ID); also elsewhere on the board
VDAC_COMP: Module1.111 (VDAC_COMP)
~FAULT: R17.2; also elsewhere on the board

Notes on the sheet:
CAM1 connector
I2C extender chip
M2?
USB_HUB chip
DSI1_connector
NEED connections!
HDMI_IN connector
CAM0 - STM32/ULX4M have direct connection to pins on board On CM4 we will need to use I2C extender chip

Parts:
C41: 4u7; C1206
J1: 5033981892; 5033981892-PCBA
R23, R24: 47K; R_0603_1608Metric

Connections:
SDMMC1_CK: J1.5 (CLK); also elsewhere on the board
SDMMC1_CMD: J1.3 (CMD), R24.2; also elsewhere on the board
SDMMC1_D0: J1.7 (DAT0), R23.2; also elsewhere on the board
SD_DETECT: J1.SW1; also elsewhere on the board

Notes on the sheet:
See AN4661 section 8.4.1
Consumption: +3.3 V, up tp 30 mA
Micro SD card socket

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
Board: 4 copper layers, 139.5 x 70.0 mm, 127 parts (19 on the bottom side), 171 nets.

Other parts of the board:
C10, C11, C12, C13, C16, C17, C18, C19: 22nF; C_0603_1608Metric
D3: 3.6V; D_SOD-323_HandSoldering
R18, R20: 549; R_0603_1608Metric
radiona: radiona

Their connections:
/CM4_IO_fast/GPDI_CEC: R18.1; also elsewhere on the board
/CM4_IO_fast/GPDI_CLK+: C13.2; also elsewhere on the board
/CM4_IO_fast/GPDI_CLK-: C19.2; also elsewhere on the board
/CM4_IO_fast/GPDI_D0+: C12.2; also elsewhere on the board
/CM4_IO_fast/GPDI_D0-: C18.2; also elsewhere on the board
/CM4_IO_fast/GPDI_D2+: C10.2; also elsewhere on the board
/CM4_IO_fast/GPDI_D2-: C16.2; also elsewhere on the board
/CM4_IO_fast/GPDI_HPD: R20.2; also elsewhere on the board
GPDI0_CEC: R18.2; also elsewhere on the board
GPDI0_CLK_N: C19.1; also elsewhere on the board
GPDI0_CLK_P: C13.1; also elsewhere on the board
GPDI0_HOTPLUG: D3.1 (K), R20.1; also elsewhere on the board
GPDI0_TX0_N: C18.1; also elsewhere on the board
GPDI0_TX0_P: C12.1; also elsewhere on the board
GPDI0_TX2_N: C16.1; also elsewhere on the board
GPDI0_TX2_P: C10.1; also elsewhere on the board

## KiCad design EEZ_BB3_CM4_R1B0/EEZ_DIB_BP3C_r3B3.kicad_pcb

Parts:
C201: 100n; C0603
D201, D202: N.C.; SOD323-R
D203, D204, D205, D206: BAS316; SOD323-R
FM201, FM202, FM203: FIDUCIAL
IC201: TCA9534PWR; PW(R-PDSO-G16)
JP201: JP3-CUT
K201, K202, K203, K204: RT424005; RT-C_016A5_ROUND
LABEL201: HR000002; CERT-SMALL-SILK
LED201, LED202, LED203, LED204: N.C.; LED_0805
Q201, Q202, Q203, Q204: SOT103P240X110-3N
R201, R202, R203, R204: 100K; R0805
R205, R206, R207, R208: N.C.; R0805
X201, X202, X203: ZL202-20G; DS1021-2*10SF11
ZD201: MM3Z18VT1G; SOD323-R

Connections:
+3V3: C201.1, IC201.16 (VCC), JP201.NO; also elsewhere on the board
+5V: K201.A2 (C1), K202.A2 (C1), K203.A2 (C1), K204.A2 (C1), LED201.A, LED202.A, LED203.A, LED204.A, ZD201.A; also elsewhere on the board
/EEZ_DIB_BP3C_r3B3_2/CH1_IN+: K203.11A, X201.6 (1), X201.7 (1), X201.8 (1), X201.9 (1), X201.10 (1)
/EEZ_DIB_BP3C_r3B3_2/CH1_OUT+: K202.14A (O), K203.12A (S), K203.14B (O), X201.1, X201.2 (1), X201.3 (1), X201.4 (1), X201.5 (1)
/EEZ_DIB_BP3C_r3B3_2/CH1_OUT-: K201.14A (O), K202.14B (O), K204.14A (O), X201.11 (1), X201.12 (1), X201.13 (1), X201.14 (1), X201.15 (1), X201.16 (1), X201.17 (1), X201.18 (1), X201.19 (1), X201.20 (1)
/EEZ_DIB_BP3C_r3B3_2/CH2_IN+: K203.11B, X202.6 (1), X202.7 (1), X202.8 (1), X202.9 (1), X202.10 (1)
/EEZ_DIB_BP3C_r3B3_2/CH2_IN-: K202.11B, K203.14A (O), X202.11 (1), X202.12 (1), X202.13 (1), X202.14 (1), X202.15 (1)
/EEZ_DIB_BP3C_r3B3_2/CH2_OUT+: K202.12A (S), K204.11A, X202.1, X202.2 (1), X202.3 (1), X202.4 (1), X202.5 (1)
/EEZ_DIB_BP3C_r3B3_2/CH2_OUT-: K201.11A, K201.11B, K202.12B (S), X202.16 (1), X202.17 (1), X202.18 (1), X202.19 (1), X202.20 (1)
/EEZ_DIB_BP3C_r3B3_2/CH3+: X203.1, X203.2 (1), X203.3 (1), X203.4 (1), X203.5 (1), X203.6 (1), X203.7 (1), X203.8 (1), X203.9 (1), X203.10 (1)
/EEZ_DIB_BP3C_r3B3_2/CH3-: K201.14B (O), X203.11 (1), X203.12 (1), X203.13 (1), X203.14 (1), X203.15 (1), X203.16 (1), X203.17 (1), X203.18 (1), X203.19 (1), X203.20 (1)
/EEZ_DIB_BP3C_r3B3_2/OUT_CGND: D201.C, IC201.4 (P0), Q201.1 (G), R201.2
/EEZ_DIB_BP3C_r3B3_2/OUT_PAR: D202.A, IC201.5 (P1), Q202.1 (G), R202.2
/EEZ_DIB_BP3C_r3B3_2/OUT_SER: D201.A, D202.C, IC201.6 (P2), Q203.1 (G), R203.2
/EEZ_DIB_BP3C_r3B3_2/OUT_SRA: IC201.7 (P3), Q204.1 (G), R204.2
BOOT1: IC201.9 (P4); also elsewhere on the board
BOOT2: IC201.10 (P5); also elsewhere on the board
BOOT3: IC201.11 (P6); also elsewhere on the board
GND: C201.2, IC201.2 (A1), IC201.3 (A2), IC201.8 (GND), JP201.NC, Q201.2 (S), Q202.2 (S), Q203.2 (S), Q204.2 (S), R201.1, R202.1, R203.1, R204.1; also elsewhere on the board
I2C1_SCL: IC201.14 (SCL); also elsewhere on the board
I2C1_SDA: IC201.15 (SDA); also elsewhere on the board
unnamed: D203.A, K201.A1 (C2), Q201.3 (D), R205.2
unnamed: D203.C, D204.C, D205.C, D206.C, ZD201.C
unnamed: D204.A, K202.A1 (C2), Q202.3 (D), R206.2
unnamed: D205.A, K203.A1 (C2), Q203.3 (D), R207.2
unnamed: D206.A, K204.A1 (C2), Q204.3 (D), R208.2
unnamed: IC201.1 (A0), JP201.COM
unnamed: K202.11A, K203.12B (S)
unnamed: LED201.C, R205.1
unnamed: LED202.C, R206.1
unnamed: LED203.C, R207.1
unnamed: LED204.C, R208.1
PROG_RST: IC201.12 (P7); also elsewhere on the board

Notes on the sheet:
18 OUT-
Power module inputs
Repository: https://github.com/eez-open
4 OUT+
20 OUT-
20-pin output power sockets
OUT- 19
OUT+ 1
OUT+ 5
Power output coupling, bootloader selection
OUT+ 3
16 OUT-
Licensed under the TAPR Open Hardware License (www.tapr.org/OHL)
IN- 13
8 IN+
2 OUT+
12 IN-
OUT- 17
6 IN+
10 IN+
More info at http://www.envox.hr/eez
Power module outputs
IN- 11
IN+ 7
IN- 15
14 IN-
IN+ 9

Parts:
C301: 1n; C0805
D301: N.C.; DO214AA
D302, D303: BAS316; SOD323-R
JP301, JP305, JP307, JP308: JP2-CUT
JP302, JP303, JP304, JP306, JP309: JP2-NOCUT
LED301, LED302: N.C.; LED_0805
R301, R302: N.C.; R0805
R303: 10K; R0805
X301, X303, X304: DS1023-2*14S21; TSW-114-07-F-D
X302: DS1022-2*20RF11; ZL212-40KG

Connections:
+3V3: C301.2, R303.1, X301.1, X302.7 (1), X303.1, X304.1; also elsewhere on the board
+5V: R301.1, X301.23 (1), X301.24 (1), X302.35 (1), X302.36 (1), X303.23 (1), X303.24 (1), X304.23 (1), X304.24 (1); also elsewhere on the board
+12V: D301.C, R302.1, X301.21 (1), X301.22 (1), X302.37 (1), X302.38 (1), X303.21 (1), X303.22 (1), X304.21 (1), X304.22 (1)
/EEZ_DIB_BP3C_r3B3_3/+VAUX: X301.2 (1), X302.5 (1), X303.2 (1), X304.2 (1)
/EEZ_DIB_BP3C_r3B3_3/OE_SYNC: X301.6 (1), X302.10 (1), X303.6 (1), X304.6 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI2_CLK: X301.13 (1), X302.32 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI2_CSA: X301.9 (1), X302.28 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI2_CSB: X301.12 (1), X302.27 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI2_IRQ: X301.10 (1), X302.25 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI2_MISO: X301.14 (1), X302.31 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI2_MOSI: X301.15 (1), X302.33 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI4_CLK: X302.23 (1), X303.13 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI4_CSA: X302.22 (1), X303.9 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI4_CSB: X302.21 (1), X303.12 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI4_CSC: X302.30 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI4_IRQ: X302.19 (1), X303.10 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI4_MISO: X302.24 (1), X303.14 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI4_MOSI: X302.26 (1), X303.15 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI5_CLK: X302.17 (1), X304.13 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI5_CSA: X302.11 (1), X304.9 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI5_CSB: X302.13 (1), X304.12 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI5_CSC: X302.34 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI5_IRQ: X302.9 (1), X304.10 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI5_MISO: X302.18 (1), X304.14 (1)
/EEZ_DIB_BP3C_r3B3_3/SPI5_MOSI: X302.20 (1), X304.15 (1)
/EEZ_DIB_BP3C_r3B3_3/UART_RX: X301.27 (1), X302.3 (1), X303.27 (1), X304.27 (1)
/EEZ_DIB_BP3C_r3B3_3/UART_TX: X301.28 (1), X302.4 (1), X303.28 (1), X304.28 (1)
/EEZ_DIB_BP3C_r3B3_3/~FAULT: X301.3 (1), X302.8 (1), X303.3 (1), X304.3 (1)
/EEZ_DIB_BP3C_r3B3_3/~MRESET: D303.C, X302.6 (1)
/EEZ_DIB_BP3C_r3B3_3/~RESET: C301.1, D302.A, D303.A, R303.2, X301.4 (1), X303.4 (1), X304.4 (1)
BOOT1: X301.26 (1); also elsewhere on the board
BOOT2: X303.26 (1); also elsewhere on the board
BOOT3: X304.26 (1); also elsewhere on the board
GND: D301.A, JP301.1, JP302.1, JP303.2, JP304.1, JP305.1, JP306.2, JP307.1, JP308.1, JP309.2, LED301.C, LED302.C, X301.7 (1), X301.11 (1), X301.16 (1), X301.25 (1), X302.1, X302.2 (1), X302.15 (1), X302.16 (1), X302.29 (1), X302.39 (1), X302.40 (1), X303.7 (1), X303.11 (1), X303.16 (1), X303.25 (1), X304.7 (1), X304.11 (1), X304.16 (1), X304.25 (1); also elsewhere on the board
I2C1_SCL: X301.5 (1), X302.12 (1), X303.5 (1), X304.5 (1); also elsewhere on the board
I2C1_SDA: X301.8 (1), X302.14 (1), X303.8 (1), X304.8 (1); also elsewhere on the board
unnamed: JP301.2, X301.17 (1)
unnamed: JP302.2, X301.19 (1)
unnamed: JP303.1, X301.18 (1)
unnamed: JP304.2, X303.17 (1)
unnamed: JP305.2, X303.19 (1)
unnamed: JP306.1, X303.18 (1)
unnamed: JP307.2, X304.17 (1)
unnamed: JP308.2, X304.19 (1)
unnamed: JP309.1, X304.18 (1)
unnamed: LED301.A, R301.2
unnamed: LED302.A, R302.2
PROG_RST: D302.C; also elsewhere on the board

Notes on the sheet:
40-pin DIB v1.1 backplane socket
UART_TX* 27
Gnd 25
18 DIB_A2
DIB_SCL 5
28 SPI1_CSA
40 Gnd
SPI1_CSB 27
10 OE_SYNC
2 +Vaux
38 +12V
28-pin data sockets
Gnd 1
SPI3_CSB 13
18 SPI3_MISO
+3V3 7
+Vaux 5
14 I2C_SDA
Licensed under the TAPR Open Hardware License (www.tapr.org/OHL)
NFAULT 3
SPI3_IRQ 9
8 NFAULT
More info at http://www.envox.hr/eez
UART_RX 3
24 SPI2_MISO
4 UART_TX
36 +5V
DIB_A1 19
26 BOOT
26 SPI2_MOSI
32 SPI1_SCLK
SPI1_IRQ 25
Peripheral modules RESET
Gnd 15
24 +5V
12 DIB_CSB
20 SPI3_MOSI
SPI3_CSA 11
6 OE_SYNC
34 SPI3_CSC
