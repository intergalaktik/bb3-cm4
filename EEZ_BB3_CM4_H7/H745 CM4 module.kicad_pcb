# Repository intergalaktik/bb3-cm4 (continued)

## KiCad design EEZ_BB3_CM4_H7/H745 CM4 module.kicad_pcb (continued)

Parts:
C3: 4u7; EC1206
C45, C46, C47, C48, C49, C50, C51, C52: 100n; C_0402_1005Metric
C53: 10u; C_0805_2012Metric
IC1: TPS2051BDBVR; DBV5
IC4: IS42S16400J; TSOPII-54
IC6: M24256-BWMN6TP; SOIC127P600X173-8N
IC7: SZNUP4114HMR6T1G; TSOP-6_1P50X3_ONS-M
IC8: IP4252CZ8-4-TTL,13; QFN8_SOT1166-1_NEX-M
R2, R4: 10K; R_0402_1005Metric
R5, R6, R18, R19: 47K; R_0402_1005Metric
R7: 4K7; R_0402_1005Metric
R14, R15, R16: 22R; R_0402_1005Metric
RN1, RN2, RN3, RN4, RN5: YC248-JR-0733RL; RES_YC248_4X1P6_YAG-M
X1: SSW-106-02-S-S
X2: TC2030-IDC; not fitted

Connections:
+5V: IC1.5 (IN); also elsewhere on the board
/SDRAM, JTAG, SD card, EEPROM/A0_IN: IC4.23 (A0), RN2.14 (2)
/SDRAM, JTAG, SD card, EEPROM/A1_IN: IC4.24 (A1), RN2.13 (2)
/SDRAM, JTAG, SD card, EEPROM/A2_IN: IC4.25 (A2), RN2.12 (2)
/SDRAM, JTAG, SD card, EEPROM/A3_IN: IC4.26 (A3), RN2.11 (2)
/SDRAM, JTAG, SD card, EEPROM/A4_IN: IC4.29 (A4), RN2.10 (2)
/SDRAM, JTAG, SD card, EEPROM/A5_IN: IC4.30 (A5), RN2.9 (2)
/SDRAM, JTAG, SD card, EEPROM/A6_IN: IC4.31 (A6), RN2.15 (2)
/SDRAM, JTAG, SD card, EEPROM/A7_IN: IC4.32 (A7), RN2.16 (2)
/SDRAM, JTAG, SD card, EEPROM/A8_IN: IC4.33 (A8), RN3.1
/SDRAM, JTAG, SD card, EEPROM/A9_IN: IC4.34 (A9), RN3.2 (1)
/SDRAM, JTAG, SD card, EEPROM/A10_IN: IC4.22 (A10/AP), RN3.3 (1)
/SDRAM, JTAG, SD card, EEPROM/A11_IN: IC4.35 (A11), RN3.4 (1)
/SDRAM, JTAG, SD card, EEPROM/BA0_IN: IC4.20 (BA0), RN1.2 (1)
/SDRAM, JTAG, SD card, EEPROM/BA1_IN: IC4.21 (BA1), RN1.1
/SDRAM, JTAG, SD card, EEPROM/CAS_IN: IC4.17 (~CAS), RN3.8 (1)
/SDRAM, JTAG, SD card, EEPROM/CKE_IN: IC4.37 (CKE), RN3.5 (1)
/SDRAM, JTAG, SD card, EEPROM/CLK_IN: IC4.38 (CLK), RN1.6 (1)
/SDRAM, JTAG, SD card, EEPROM/CS_IN: IC4.19 (~CS), RN3.6 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ0_IN: IC4.2 (DQ0), RN4.5 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ1_IN: IC4.4 (DQ1), RN4.4 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ2_IN: IC4.5 (DQ2), RN4.3 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ3_IN: IC4.7 (DQ3), RN4.1
/SDRAM, JTAG, SD card, EEPROM/DQ4_IN: IC4.8 (DQ4), RN5.1
/SDRAM, JTAG, SD card, EEPROM/DQ5_IN: IC4.10 (DQ5), RN5.2 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ6_IN: IC4.11 (DQ6), RN5.4 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ7_IN: IC4.13 (DQ7), RN1.7 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ8_IN: IC4.42 (DQ8), RN1.8 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ9_IN: IC4.44 (DQ9), RN5.3 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ10_IN: IC4.45 (DQ10), RN5.5 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ11_IN: IC4.47 (DQ11), RN5.6 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ12_IN: IC4.48 (DQ12), RN5.7 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ13_IN: IC4.50 (DQ13), RN4.6 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ14_IN: IC4.51 (DQ14), RN4.7 (1)
/SDRAM, JTAG, SD card, EEPROM/DQ15_IN: IC4.53 (DQ15), RN4.8 (1)
/SDRAM, JTAG, SD card, EEPROM/LDQM_IN: IC4.15 (LDQM), RN1.4 (1)
/SDRAM, JTAG, SD card, EEPROM/RAS_IN: IC4.18 (~RAS), RN1.5 (1)
/SDRAM, JTAG, SD card, EEPROM/SWD_NRST: IC7.4 (IO4), R15.2, X1.5 (1), X2.3 (~RESET)
/SDRAM, JTAG, SD card, EEPROM/TCK: IC7.1 (IO2), R16.2, X1.2 (1), X2.4 (SWCLK)
/SDRAM, JTAG, SD card, EEPROM/TMS: IC7.6 (IO1), R14.2, X1.4 (1), X2.2 (SWDIO)
/SDRAM, JTAG, SD card, EEPROM/UDQM_IN: IC4.39 (UDQM), RN1.3 (1)
/SDRAM, JTAG, SD card, EEPROM/WE_IN: IC4.16 (~WE), RN3.7 (1)
CM4_3.3V: C45.1, C46.1, C47.1, C48.1, C49.1, C50.1, C51.1, C52.2, C53.1, IC4.1 (VDD-1), IC4.3 (VDDQ-3), IC4.9 (VDDQ-9), IC4.14 (VDD-14), IC4.27 (VDD-27), IC4.43 (VDDQ-43), IC4.49 (VDDQ-49), IC6.8 (VCC), IC7.5 (VCC), R5.2, R6.1, R18.1, R19.1; also elsewhere on the board
FMC_A0: RN2.3 (1); also elsewhere on the board
FMC_A1: RN2.4 (1); also elsewhere on the board
FMC_A2: RN2.5 (1); also elsewhere on the board
FMC_A3: RN2.6 (1); also elsewhere on the board
FMC_A4: RN2.7 (1); also elsewhere on the board
FMC_A5: RN2.8 (1); also elsewhere on the board
FMC_A6: RN2.2 (1); also elsewhere on the board
FMC_A7: RN2.1; also elsewhere on the board
FMC_A8: RN3.16 (2); also elsewhere on the board
FMC_A9: RN3.15 (2); also elsewhere on the board
FMC_A10: RN3.14 (2); also elsewhere on the board
FMC_A11: RN3.13 (2); also elsewhere on the board
FMC_BA0: RN1.15 (2); also elsewhere on the board
FMC_BA1: RN1.16 (2); also elsewhere on the board
FMC_D0: RN4.12 (2); also elsewhere on the board
FMC_D1: RN4.13 (2); also elsewhere on the board
FMC_D2: RN4.14 (2); also elsewhere on the board
FMC_D3: RN4.16 (2); also elsewhere on the board
FMC_D4: RN5.16 (2); also elsewhere on the board
FMC_D5: RN5.15 (2); also elsewhere on the board
FMC_D6: RN5.13 (2); also elsewhere on the board
FMC_D7: RN1.10 (2); also elsewhere on the board
FMC_D8: RN1.9 (2); also elsewhere on the board
FMC_D9: RN5.14 (2); also elsewhere on the board
FMC_D10: RN5.12 (2); also elsewhere on the board
FMC_D11: RN5.11 (2); also elsewhere on the board
FMC_D12: RN5.10 (2); also elsewhere on the board
FMC_D13: RN4.11 (2); also elsewhere on the board
FMC_D14: RN4.10 (2); also elsewhere on the board
FMC_D15: RN4.9 (2); also elsewhere on the board
FMC_NBL0: RN1.13 (2); also elsewhere on the board
FMC_NBL1: RN1.14 (2); also elsewhere on the board
FMC_SDCKE0: RN3.12 (2); also elsewhere on the board
FMC_SDCLK: RN1.11 (2); also elsewhere on the board
FMC_SDNCAS: RN3.9 (2); also elsewhere on the board
FMC_SDNE0: RN3.11 (2); also elsewhere on the board
FMC_SDNRAS: RN1.12 (2); also elsewhere on the board
FMC_SDNWE: RN3.10 (2); also elsewhere on the board
GND: C3.-, C45.2, C46.2, C47.2, C48.2, C49.2, C50.2, C51.2, C52.1, C53.2, IC1.2 (GND), IC4.6 (GNDQ-6), IC4.12 (GNDQ-12), IC4.28 (GND-28), IC4.41 (GND-41), IC4.46 (GNDQ-46), IC4.52 (GNDQ-52), IC4.54 (GND-54), IC6.1 (A0), IC6.2 (A1), IC6.3 (A2), IC6.4 (GND), IC6.7 (WP), IC7.2 (GND), IC8.9 (GND), R2.1, R4.2, X1.3 (1), X2.5 (GND); also elsewhere on the board
HDMI0_CLK_P: R4.1, R7.2; also elsewhere on the board
HDMI0_TX0_N: IC1.3 (~OC); also elsewhere on the board
HDMI0_TX0_P: IC1.4 (EN), R2.2; also elsewhere on the board
I2C1_SCL: IC6.6 (SCL); also elsewhere on the board
I2C1_SDA: IC6.5 (SDA); also elsewhere on the board
unnamed: C3.+, IC1.1 (OUT), R7.1
SDMMC1_CK: IC8.3 (IN.3); also elsewhere on the board
SDMMC1_CMD: IC8.2 (IN.2), R19.2; also elsewhere on the board
SDMMC1_D0: IC8.4 (IN.4), R18.2; also elsewhere on the board
SD_CLK: IC8.6 (OUT.3); also elsewhere on the board
SD_CMD: IC8.7 (OUT.2); also elsewhere on the board
SD_DAT0: IC8.5 (OUT.4); also elsewhere on the board
SD_DETECT: IC8.1 (IN.1), IC8.8 (OUT.1), R5.1, R6.2; also elsewhere on the board
SYS_JTCK-SWCLK: R16.1; also elsewhere on the board
SYS_JTDO-SWO: IC7.3 (IO3), X1.6 (1), X2.6 (SWO); also elsewhere on the board
SYS_JTMS-SWDIO: R14.1; also elsewhere on the board
~RESET: R15.1; also elsewhere on the board

Notes on the sheet:
Tant.
Consumption: +3.3 V, up tp 30 mA
SWDIO 2
NRST 5
SWDIO 4
Micro SD card socket
64/128 Mb SDRAM
1 N.C.
Gnd 3
I2C EEPROM
SWO 6
Consumption: +3.3 V, up to 110 mA
PCB pads for Tag-Connect TC2030-CTX
IMPORTANT: For PCB layout consult ST AN4938 section 9.4.3
3 nRST
5 GND
128 Mb pin-compatible option: IS42S16800F-6TL or W9812G6KH-6
SWCLK 2
STM-32 board SWD
N.C. 1
Pull-down to disconnect VBUS in bootloader mode
SWCLK 4
USB OTG port
See AN4661 section 8.4.1
Decoupling capacitors have to be as close as possible to the pins
I2C address: 0x50
JTAG/SWD (optional)

Board: 6 copper layers, 55.1 x 40.0 mm, 120 parts (71 on the bottom side), 186 nets.

Other parts of the board:
radiona: radiona

## KiCad design EEZ_DIB_MCU_r3B4/EEZ_DIB_MCU_r3B4.kicad_pcb

Parts:
IC9: N.C.; SOT23-5L_STM
JP6: JP3-CUT-0805-ROTATED; JP3-0805-CUT2
R25: N.C.; R_0603_1608Metric

Connections:
unnamed: IC9.3 (RST), JP6.NO
unnamed: IC9.1 (~RST), R25.1
PDR_ON: JP6.COM
WDG: IC9.4 (WDI)
~RESET: R25.2; also elsewhere on the board

Notes on the sheet:
Watchdog/supervisor (optional)

Parts:
C40: 100n; C_0603_1608Metric
IC8: AT24C256C-SSHL-B; SOIC127P600X173-8N

Connections:
I2C1_SCL: IC8.6 (SCL); also elsewhere on the board
I2C1_SDA: IC8.5 (SDA); also elsewhere on the board

Notes on the sheet:
I2C address read: 0xA1
I2C EEPROM
I2C address write: 0xA0

Parts:
C26: C_Small; C_0603_1608Metric
J3: HR911130A; HANRUN_HR911130A; PARTREV A
Module1: ComputeModule4-CM4; Raspberry-Pi-4-Compute-Module
R22, R38, R39: R_Small; R_0603_1608Metric

Connections:
+5V: Module1.77 (+5v_(Input)), Module1.79 (+5v_(Input)), Module1.81 (+5v_(Input)), Module1.83 (+5v_(Input)), Module1.85 (+5v_(Input)), Module1.87 (+5v_(Input)); also elsewhere on the board
/CM4_IO_slow/ETH_0N: J3.3, Module1.10 (Ethernet_Pair0_N)
/CM4_IO_slow/ETH_0P: J3.2, Module1.12 (Ethernet_Pair0_P)
/CM4_IO_slow/ETH_1N: J3.7, Module1.6 (Ethernet_Pair1_N)
/CM4_IO_slow/ETH_1P: J3.4, Module1.4 (Ethernet_Pair1_P)
/CM4_IO_slow/ETH_2N: J3.6, Module1.11 (Ethernet_Pair2_P)
/CM4_IO_slow/ETH_2P: J3.5, Module1.9 (Ethernet_Pair2_N)
/CM4_IO_slow/ETH_3N: J3.9, Module1.5 (Ethernet_Pair3_N)
/CM4_IO_slow/ETH_3P: J3.8, Module1.3 (Ethernet_Pair3_P)
/CM4_IO_slow/eth_led1: Module1.19 (Ethernet_nLED1(3.3v)), R39.2
/CM4_IO_slow/eth_led2: Module1.17 (Ethernet_nLED2(3.3v)), R38.2
/CM4_IO_slow/eth_led3: Module1.15 (Ethernet_nLED3(3.3v))
ACT_LED: Module1.21 (PI_nLED_Activity)
ADC1_IN5: Module1.96 (AnalogIP0)
ADC2_IN6: Module1.94 (AnalogIP1)
BOOT0: Module1.93 (nRPIBOOT); also elsewhere on the board
CAM_GPIO: Module1.97 (Camera_GPIO)
DAC_OUT1: Module1.34 (GPIO5); also elsewhere on the board
DIN2: Module1.41 (GPIO25); also elsewhere on the board
DOUT2: Module1.29 (GPIO16); also elsewhere on the board
ENC_A: Module1.58 (GPIO2); also elsewhere on the board
ENC_B: Module1.56 (GPIO3); also elsewhere on the board
ENC_SW: Module1.45 (GPIO24); also elsewhere on the board
EN_GPIO: Module1.99 (Global_EN)
I2C1_SCL: Module1.80 (SCL0); also elsewhere on the board
I2C1_SDA: Module1.82 (SDA0); also elsewhere on the board
IRQ_TOUCH: Module1.54 (GPIO4); also elsewhere on the board
unnamed: C26.2, J3.1
unnamed: J3.10, R22.1
unnamed: J3.11, R38.1
unnamed: J3.14, R39.1
RESET: Module1.100 (nEXTRST)
SDMMC1_CK: Module1.57 (SD_CLK); also elsewhere on the board
SDMMC1_CMD: Module1.62 (SD_CMD); also elsewhere on the board
SDMMC1_D0: Module1.63 (SD_DAT0); also elsewhere on the board
SD_DETECT: Module1.75 (SD_PWR_ON); also elsewhere on the board
SPI2_CLK: Module1.38 (GPIO11); also elsewhere on the board
SPI2_CSA: Module1.39 (GPIO8); also elsewhere on the board
SPI2_CSB: Module1.37 (GPIO7); also elsewhere on the board
SPI2_IRQ: Module1.30 (GPIO6); also elsewhere on the board
SPI2_MISO: Module1.40 (GPIO9); also elsewhere on the board
SPI2_MOSI: Module1.44 (GPIO10); also elsewhere on the board
SPI4_CLK: Module1.25 (GPIO21); also elsewhere on the board
SPI4_CSA: Module1.49 (GPIO18); also elsewhere on the board
SPI4_CSB: Module1.50 (GPIO17); also elsewhere on the board
SPI4_IRQ: Module1.48 (GPIO27); also elsewhere on the board
SPI4_MISO: Module1.26 (GPIO19); also elsewhere on the board
SPI4_MOSI: Module1.27 (GPIO20); also elsewhere on the board
SPI5_CLK: Module1.51 (GPIO15); also elsewhere on the board
SPI5_CSA: Module1.31 (GPIO12); also elsewhere on the board
SPI5_CSB: Module1.24 (GPIO26); also elsewhere on the board
SPI5_IRQ: Module1.46 (GPIO22); also elsewhere on the board
SPI5_MISO: Module1.28 (GPIO13); also elsewhere on the board
SPI5_MOSI: Module1.55 (GPIO14); also elsewhere on the board
USER_SW: Module1.47 (GPIO23); also elsewhere on the board

Parts:
C50, C56: 4u7; C1206
C51, C58: 1u; C_0603_1608Metric
C52: 4u7; EC1206
C53: 2u2; C_0603_1608Metric
C54: 4n7/1kV; C1812
C55, C57: 100n; C_0603_1608Metric
D2: RB751V40T1G; SOD323-R
IC11: TPS2051BDBVR; DBV5
IC12: TPS61169DCKR; DCK5
IC13: TPD4E001DRLR; DRL6
IC14: TSC2007IPW; PW(R-PDSO-G16)
J2: 67803-8020; 678038020
JP9: JP2-NOCUT-0805; JP2-0805-NOCUT
L2: DLG-0403-4R7; DE0403
LCD1: 505110-4091; FPC_40
LED1: N.C.; LED_0805
Q1: N.C.; SOT23-BEC
Q2: 2N7002; SOT103P240X110-3N
R26, R29: 10R; R_0603_1608Metric
R27, R30: N.C.; R_0603_1608Metric
R28, R34, R37: 10K; R_0603_1608Metric
R31: 4K7; R_0603_1608Metric
R32, R33: 22R; R_0603_1608Metric
R35, R36: 470K; R_0603_1608Metric
SP1: LD-BZEN 0903; LD-BZEN_COMBO
ZD1: BZX384-B24.115; SOD323-W

Connections:
+5V: C50.1, IC11.5 (IN), L2.1, R26.1; also elsewhere on the board
/TFT LCD Audio USB/LCD_DISP: LCD1.31 (DISP), R37.1
/TFT LCD Audio USB/USB_D_N: IC13.1 (IO1), J2.2 (D-), R32.1
/TFT LCD Audio USB/USB_D_P: IC13.2 (IO2), J2.3 (D+), R33.1
/TFT LCD Audio USB/VLED+: C51.1, D2.C, LCD1.2 (VLED+), ZD1.C
/TFT LCD Audio USB/VLED-: IC12.3 (FB), LCD1.1 (VLED-), R29.1, ZD1.A
/TFT LCD Audio USB/XL: IC14.4 (X-), LCD1.39 (XL)
/TFT LCD Audio USB/XR: IC14.2 (X+), LCD1.37 (XR)
/TFT LCD Audio USB/YD: IC14.5 (Y-), LCD1.38 (YD)
/TFT LCD Audio USB/YU: IC14.3 (Y+), LCD1.40 (YU)
DAC_OUT1: Q2.1 (G); also elsewhere on the board
I2C1_SCL: IC14.12 (SCL); also elsewhere on the board
I2C1_SDA: IC14.11 (SDA); also elsewhere on the board
IRQ_TOUCH: IC14.10 (~PENIRQ); also elsewhere on the board
LTDC_B0: LCD1.21 (B0); also elsewhere on the board
LTDC_B1: LCD1.22 (B1); also elsewhere on the board
LTDC_B2: LCD1.23 (B2); also elsewhere on the board
LTDC_B3: LCD1.24 (B3); also elsewhere on the board
LTDC_B4: LCD1.25 (B4); also elsewhere on the board
LTDC_B5: LCD1.26 (B5); also elsewhere on the board
LTDC_B6: LCD1.27 (B6); also elsewhere on the board
LTDC_B7: LCD1.28 (B7); also elsewhere on the board
LTDC_CLK: LCD1.30 (CLK); also elsewhere on the board
LTDC_DE: LCD1.34 (DE/NC2); also elsewhere on the board
LTDC_G0: LCD1.13 (G0); also elsewhere on the board
LTDC_G1: LCD1.14 (G1); also elsewhere on the board
LTDC_G2: LCD1.15 (G2); also elsewhere on the board
LTDC_G3: LCD1.16 (G3); also elsewhere on the board
LTDC_G4: LCD1.17 (G4); also elsewhere on the board
LTDC_G5: LCD1.18 (G5); also elsewhere on the board
LTDC_G6: LCD1.19 (G6); also elsewhere on the board
LTDC_G7: LCD1.20 (G7); also elsewhere on the board
LTDC_HSYNC: LCD1.32 (HSYNC); also elsewhere on the board
LTDC_R0: LCD1.5 (R0); also elsewhere on the board
LTDC_R1: LCD1.6 (R1); also elsewhere on the board
LTDC_R2: LCD1.7 (R2); also elsewhere on the board
LTDC_R3: LCD1.8 (R3); also elsewhere on the board
LTDC_R4: LCD1.9 (R4); also elsewhere on the board
LTDC_R5: LCD1.10 (R5); also elsewhere on the board
LTDC_R6: LCD1.11 (R6); also elsewhere on the board
LTDC_R7: LCD1.12 (R7); also elsewhere on the board
LTDC_VSYNC: LCD1.33 (VSYNC); also elsewhere on the board
unnamed: C52.+, C55.2, IC11.1 (OUT), IC13.6 (VCC), J2.1 (VCC), R30.1, R31.1
unnamed: D2.A, IC12.1 (SW), L2.2
unnamed: IC12.5 (VIN), R26.2
unnamed: JP9.1, LCD1.36 (RESET)
unnamed: LED1.C, R27.2
unnamed: Q1.B, R30.2
unnamed: Q1.C, R27.1
unnamed: Q2.3 (D), SP1.-, SP1.-B (-)
unnamed: R35.1, R36.2
PE: C54.2, J2.SH1, J2.SH1.1 (SH1), J2.SH2, J2.SH2.2 (SH2), R36.1; also elsewhere on the board
TFT_BRIGHTNESS: IC12.4 (CTRL); also elsewhere on the board
USB_OTG_FS_D_N: R32.2; also elsewhere on the board
USB_OTG_FS_D_P: R33.2; also elsewhere on the board
USB_OTG_FS_ID: IC13.4 (IO3), J2.4 (ID); also elsewhere on the board
USB_OTG_FS_PSO: IC11.4 (EN), R28.2
USB_OTG_FS_VBUS: R31.2, R34.1
~USB_OTG_FS_OC: IC11.3 (~OC)

Notes on the sheet:
Resistive touchscreen controller
Tant.
+22.5V
Audio output
Missing?
Pull-down to disconnect VBUS in bootloader mode
LCD backlight DC-DC step-up converter
USB, TFT LCD, touchscreen, audio amplifier
LCD display: RFE43BH-AIW-DNS or RFE430Y-AIW-DNS 4.3", 480x272, resistive touch screen
Vfb = 0.204 V
USB OTG port
Consumption: +3.3 V, max. 33 mA; +32 V, 20 mA
4.3" LCD 40-pin socket

Parts:
C14: EEEFK1V220R; PANASONIC_C
C15: 100n; C_0603_1608Metric
D1: SMBJ5.0A-TR; DO214AA
IC5: LD1117ADT33TR; DPACK

Connections:
+5V: C14.1 (+), C15.1, D1.C, IC5.3 (IN); also elsewhere on the board
